/*@!Encoding:1252*/

includes
{
  
  #include "..\..\ProjectSpecific\GenLib_Includes.cin"

}

variables
{
  char chTestDescription[500];
  char chActionText[500];
  char chExpectedText[500];
  char chTestTitle[100];
  
  byte dat_102[3] = {0xAA,0x55,0xAA};
  mstimer delay;
  
  long test_exc_address_value;
  long ResetSrc_value;
  long VeTEST_InvalidOperationsRes7_value;  
  long VeTEST_InvalidOperations_value_NAN;   
  long VeTEST_InvalidOperations_value_INF; 
  long VeTEST_FloatCvrt_ftouz_MaxPosL_value;
}

  on timer delay 
  {
    write("wait for 3 Sec");
  }

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425892: Verify Divide by Zero Scenerio 1
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of a division by zero exception.

***************************************************************************************************/
testcase Testcase_Verify_Divide_by_Zero_Scenerio_1_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Divide_by_Zero_Scenerio_1_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of a division by zero exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425892", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_DivByZeroNum = 5.0f and VeTEST_PosZero = 0.0f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_DivByZeroNum = 5.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_DivByZeroNum = 5.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_DivByZeroNum", "5.0");  
  E_DBGR_VariableCheck("VeTEST_DivByZeroNum", 5.0, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_PosZero = 0.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_PosZero = 0.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_PosZero", "0.0");
  E_DBGR_VariableCheck("VeTEST_PosZero", 0.0, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_DivideByPosZero = VeTEST_DivByZeroNum / VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_DivideByPosZero = VeTEST_DivByZeroNum / VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\10");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\10");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_DivideByPosZero = VeTEST_DivByZeroNum / VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_DivideByPosZero value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_DivideByPosZero value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_DivideByPosZero is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_DivideByPosZero",340.28235E36,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425893: Verify Divide by Zero Scenerio 2
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of a division by zero exception.

***************************************************************************************************/
testcase Testcase_Verify_Divide_by_Zero_Scenerio_2_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Divide_by_Zero_Scenerio_2_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of a division by zero exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425893", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_DivByZeroNum = 5.0f and VeTEST_NegZero = -0.0f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_DivByZeroNum = 5.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_DivByZeroNum = 5.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_DivByZeroNum", "5.0");  
  E_DBGR_VariableCheck("VeTEST_DivByZeroNum", 5.0, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_NegZero = -0.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_NegZero = -0.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_NegZero", "-0.0");
  E_DBGR_VariableCheck("VeTEST_NegZero", -0.0, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_DivideByNegZero = VeTEST_DivByZeroNum / VeTEST_NegZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_DivideByNegZero = VeTEST_DivByZeroNum / VeTEST_NegZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_DivideByNegZero = VeTEST_DivByZeroNum / VeTEST_NegZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_DivideByNegZero  value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_DivideByNegZero  value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_DivideByNegZero is -340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_DivideByNegZero",-340.28235E36,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425894: Verify Divide by Zero Scenerio 3
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of a division by zero exception.

***************************************************************************************************/
testcase Testcase_Verify_Divide_by_Zero_Scenerio_3_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Divide_by_Zero_Scenerio_3_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of a division by zero exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425894", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: VeTEST_FloatPos_1 = 2.8 and VeTEST_PosZero = 0.0
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_1 = 2.8f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_1 = 2.8f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_1", "2.8");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_1", 2.8, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_PosZero = 0.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_PosZero = 0.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_PosZero", "0.0");
  E_DBGR_VariableCheck("VeTEST_PosZero", 0.0, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_DivideByPosZero_1 = VeTEST_FloatPos_1 / VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_DivideByPosZero_1 = VeTEST_FloatPos_1 / VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\12");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\12");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_DivideByPosZero_1 = VeTEST_FloatPos_1 / VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_DivideByPosZero_1 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_DivideByPosZero_1 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_DivideByPosZero_1 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_DivideByPosZero_1",340.28235E36,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425895: Round Towards Zero Scenerio 1
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to set the rounding mode to round toward zero.

***************************************************************************************************/
testcase Testcase_Verify_Round_Towards_Zero_Scenerio_1_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Round_Towards_Zero_Scenerio_1_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to set the rounding mode to round toward zero.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425895", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_FloatPos = 2.8f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos = 2.8f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos = 2.8f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos", "2.8");  
  E_DBGR_VariableCheck("VeTEST_FloatPos", 2.8, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_FloatCvtPos = (LONGWORD)(VeTEST_FloatPos);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_FloatCvtPos = (LONGWORD)(VeTEST_FloatPos); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\15");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\15");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_FloatCvtPos = (LONGWORD)(VeTEST_FloatPos); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_FloatCvtPos  value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvtPos  value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvtPos is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvtPos ",2,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425896: Verify Round Towards Zero Scenerio 2
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to set the rounding mode to round toward zero.

***************************************************************************************************/
testcase Testcase_Verify_Round_Towards_Zero_Scenerio_2_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Round_Towards_Zero_Scenerio_2_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to set the rounding mode to round toward zero.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425896", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_FloatNeg = -1.9f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatNeg = -1.9f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatNeg = -1.9f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatNeg", "-1.9");  
  E_DBGR_VariableCheck("VeTEST_FloatNeg", -1.9, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_FloatCvtNeg = (LONGWORD)(VeTEST_FloatNeg);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_FloatCvtNeg = (LONGWORD)(VeTEST_FloatNeg); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\16");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\16");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_FloatCvtNeg = (LONGWORD)(VeTEST_FloatNeg); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_FloatCvtNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvtNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvtNeg is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvtNeg",0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425897: Verify Round Towards Zero Scenerio 3
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to set the rounding mode to round toward zero.

***************************************************************************************************/
testcase Testcase_Verify_Round_Towards_Zero_Scenerio_3_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Round_Towards_Zero_Scenerio_3_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to set the rounding mode to round toward zero.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425897", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_FloatNeg = -1.9f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatNeg = -1.9f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatNeg = -1.9f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatNeg", "-1.9");  
  E_DBGR_VariableCheck("VeTEST_FloatNeg", -1.9, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_FloatCvtNeg2 = (INTEGER)(VeTEST_FloatNeg);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_FloatCvtNeg2 = (INTEGER)(VeTEST_FloatNeg); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\17");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\17");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_FloatCvtNeg2 = (INTEGER)(VeTEST_FloatNeg); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_FloatCvtNeg2 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvtNeg2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvtNeg2 is -1.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvtNeg2",-1.0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425898: Verify Inexact Exception Scenerio 1
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to take no action upon occurrence of an inexact exception.

***************************************************************************************************/
testcase Testcase_Verify_Inexact_Exception_Scenerio_1_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Inexact_Exception_Scenerio_1_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to take no action upon occurrence of an inexact exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425898", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3:Set VeTEST_FloatNum = 2.0f and VeTEST_FloatDen = 3.0f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatNum = 2.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatNum = 2.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatNum", "2.0");  
  E_DBGR_VariableCheck("VeTEST_FloatNum", 2.0, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatDen = 3.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatDen = 3.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatDen", "3.0");
  E_DBGR_VariableCheck("VeTEST_FloatDen", 3.0, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InexactResult = VeTEST_FloatNum/VeTEST_FloatDen;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InexactResult = VeTEST_FloatNum/VeTEST_FloatDen; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\20");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\20");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InexactResult = VeTEST_FloatNum/VeTEST_FloatDen; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_InexactResult value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InexactResult value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InexactResult is 0.66666663"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InexactResult",0.66666663,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425899: Verify Inexact Exception Scenerio 2
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to take no action upon occurrence of an inexact exception.

***************************************************************************************************/
testcase Testcase_Verify_Inexact_Exception_Scenerio_2_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Inexact_Exception_Scenerio_2_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to take no action upon occurrence of an inexact exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425899", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_FloatNum_1 = 4.0f and VeTEST_FloatDen_1 = 7.0f
  /*******************************************************************************************************************************************************/
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatNum_1 = 4.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatNum_1 = 4.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatNum_1", "4.0");  
  E_DBGR_VariableCheck("VeTEST_FloatNum_1", 4.0, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatDen_1 = 7.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatDen_1 = 7.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatDen_1", "7.0");
  E_DBGR_VariableCheck("VeTEST_FloatDen_1", 7.0, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InexactResult_1 = VeTEST_FloatNum_1/VeTEST_FloatDen_1;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InexactResult_1 = VeTEST_FloatNum_1/VeTEST_FloatDen_1; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\21");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\21");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InexactResult_1 = VeTEST_FloatNum_1/VeTEST_FloatDen_1; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_InexactResult_1 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InexactResult_1 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InexactResult_1 is 0.57142854"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InexactResult_1",0.57142854,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425900: Verify Underflow Scenerio 1
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide a result of 0 with the sign of the intermediate result, upon the occurrence of an underflow exception.

***************************************************************************************************/
testcase Testcase_Verify_Underflow_Scenerio_1_Core0() 
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Underflow_Scenerio_1_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide a result of 0 with the sign of the intermediate result, upon the occurrence of an underflow exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425900", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3:Set Set VeTEST_FloatMinNormPos.myFloat = 1.17549435E-38
  /*******************************************************************************************************************************************************/
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMinNormPos.myFloat = 0x00800000"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMinNormPos.myFloat = 0x00800000"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMinNormPos.myFloat", "0x00800000");  
//  E_DBGR_VariableCheck("VeTEST_FloatMinNormPos.myFloat", 0x00800000, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_UnderflowMin_x_Min = VeTEST_FloatMinNormPos.myFloat * VeTEST_FloatMinNormPos.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_UnderflowMin_x_Min = VeTEST_FloatMinNormPos.myFloat * VeTEST_FloatMinNormPos.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\24");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\24");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_UnderflowMin_x_Min = VeTEST_FloatMinNormPos.myFloat * VeTEST_FloatMinNormPos.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_UnderflowMin_x_Min value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_UnderflowMin_x_Min value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_UnderflowMin_x_Min is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_UnderflowMin_x_Min",0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425901: Verify Underflow Scenerio 2
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide a result of 0 with the sign of the intermediate result, upon the occurrence of an underflow exception.

***************************************************************************************************/
testcase Testcase_Verify_Underflow_Scenerio_2_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Underflow_Scenerio_2_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide a result of 0 with the sign of the intermediate result, upon the occurrence of an underflow exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425901", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set Set VeTEST_FloatMinNormPos.myFloat = 1.17549435E-38 and VeTEST_FloatMinNormNeg.myFloat = -1.17549435E-38
  /*******************************************************************************************************************************************************/
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMinNormPos = 1.17549435E-38"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMinNormPos = 1.17549435E-38"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMinNormPos", "1.17549435E-38");  
//  E_DBGR_VariableCheck("VeTEST_FloatMinNormPos", 1.17549435E-38, Equal);
  
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMinNormNeg = -1.17549435E-38"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMinNormNeg = -1.17549435E-38"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMinNormNeg", "-1.17549435E-38");
//  E_DBGR_VariableCheck("VeTEST_FloatMinNormNeg", -1.17549435E-38, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_UnderflowMin_Div_MinNeg = VeTEST_FloatMinNormPos.myFloat / VeTEST_FloatMinNormNeg.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_UnderflowMin_Div_MinNeg = VeTEST_FloatMinNormPos.myFloat / VeTEST_FloatMinNormNeg.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\25");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\25");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_UnderflowMin_Div_MinNeg = VeTEST_FloatMinNormPos.myFloat / VeTEST_FloatMinNormNeg.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_UnderflowMin_Div_MinNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_UnderflowMin_Div_MinNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_UnderflowMin_Div_MinNeg is -1.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_UnderflowMin_Div_MinNeg",-1.0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425902: Verify Underflow Scenerio 3
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide a result of 0 with the sign of the intermediate result, upon the occurrence of an underflow exception.

***************************************************************************************************/
testcase Testcase_Verify_Underflow_Scenerio_3_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Underflow_Scenerio_3_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide a result of 0 with the sign of the intermediate result, upon the occurrence of an underflow exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425902", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set Set VeTEST_FloatMinNormPos.myFloat = 1.17549435E-38 and VeTEST_FloatMinNormNeg.myFloat = -1.17549435E-38
  /*******************************************************************************************************************************************************/
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMinNormPos = 1.17549435E-38"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMinNormPos = 1.17549435E-38"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMinNormPos", "1.17549435E-38");  
//  E_DBGR_VariableCheck("VeTEST_FloatMinNormPos", 1.17549435E-38, Equal);
  
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMinNormNeg = -1.17549435E-38"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMinNormNeg = -1.17549435E-38"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMinNormNeg", "-1.17549435E-38");
//  E_DBGR_VariableCheck("VeTEST_FloatMinNormNeg", -1.17549435E-38, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_UnderflowMin_Div_MinNeg = VeTEST_FloatMinNormPos.myFloat / VeTEST_FloatMinNormNeg.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_UnderflowMin_Div_MinNeg = VeTEST_FloatMinNormPos.myFloat / VeTEST_FloatMinNormNeg.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\25");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\25");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_UnderflowMin_Div_MinNeg = VeTEST_FloatMinNormPos.myFloat / VeTEST_FloatMinNormNeg.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_UnderflowMin_Div_MinNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_UnderflowMin_Div_MinNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_UnderflowMin_Div_MinNeg is -1.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_UnderflowMin_Div_MinNeg",-1.0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425903: Verify Overflow Scenerio Scenerio 1
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide a result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of an overflow exception.

***************************************************************************************************/
testcase Testcase_Verify_Overflow_Scenerio_1_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Overflow_Scenerio_1_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide a result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of an overflow exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425903", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_FloatMaxNormPos.myFloat = 340.28235E36
  /*******************************************************************************************************************************************************/
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMaxNormPos = 340.28235E36"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMaxNormPos = 340.28235E36"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMaxNormPos", "340.28235E36");  
//  E_DBGR_VariableCheck("VeTEST_FloatMaxNormPos", 340.28235E36, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_OverflowMax_x_Max = VeTEST_FloatMaxNormPos.myFloat * VeTEST_FloatMaxNormPos.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_OverflowMax_x_Max = VeTEST_FloatMaxNormPos.myFloat * VeTEST_FloatMaxNormPos.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\29");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\29");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_OverflowMax_x_Max = VeTEST_FloatMaxNormPos.myFloat * VeTEST_FloatMaxNormPos.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_OverflowMax_x_Max value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_OverflowMax_x_Max value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_OverflowMax_x_Max is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_OverflowMax_x_Max",340.28235E36,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425904: Verify Overflow Scenerio 2
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide a result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of an overflow exception.

***************************************************************************************************/
testcase Testcase_Verify_Overflow_Scenerio_2_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Overflow_Scenerio_2_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide a result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of an overflow exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425904", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_FloatMaxNormPos.myFloat = 340.28235E36 and VeTEST_FloatMaxNormNeg.myFloat = -340.28235E36 in watch window
  /*******************************************************************************************************************************************************/
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMaxNormPos = 340.28235E36"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMaxNormPos = 340.28235E36"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMaxNormPos", "340.28235E36");  
//  E_DBGR_VariableCheck("VeTEST_FloatMaxNormPos", 340.28235E36, Equal);
  
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMaxNormNeg = -340.28235E38"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMaxNormNeg = -340.28235E38"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMaxNormNeg", "-340.28235E38");
//  E_DBGR_VariableCheck("VeTEST_FloatMaxNormNeg", -340.28235E38, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_OverflowMax_x_MaxNeg = VeTEST_FloatMaxNormPos.myFloat * VeTEST_FloatMaxNormNeg.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_OverflowMax_x_MaxNeg = VeTEST_FloatMaxNormPos.myFloat * VeTEST_FloatMaxNormNeg.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\30");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\30");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_OverflowMax_x_MaxNeg = VeTEST_FloatMaxNormPos.myFloat * VeTEST_FloatMaxNormNeg.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_OverflowMax_x_MaxNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_OverflowMax_x_MaxNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_OverflowMax_x_MaxNeg is -340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_OverflowMax_x_MaxNeg",-340.28235E36,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425905: Verify Invalid Operations without running reset Divide Zero by Zero Scenerio 1
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide a result of 0 with a sign of the Exclusive-OR of the operands’ signs, for an invalid operation of 0/0.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_without_running_reset_Divide_Zero_by_Zero_Scenerio_1_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_without_running_reset_Divide_Zero_by_Zero_Scenerio_1_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide a result of 0 with a sign of the Exclusive-OR of the operands’ signs, for an invalid operation of 0/0.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425905", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_PosZero = 0.0f
  /*******************************************************************************************************************************************************/
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_PosZero = 0.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_PosZero = 0.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_PosZero", "0.0");  
  E_DBGR_VariableCheck("VeTEST_PosZero", 0.0, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_Zero_Div_Zero = VeTEST_PosZero / VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_Zero_Div_Zero = VeTEST_PosZero / VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\33");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\33");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_Zero_Div_Zero = VeTEST_PosZero / VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_Zero_Div_Zero value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Zero_Div_Zero value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Zero_Div_Zero is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Zero_Div_Zero",0.0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425906: Verify Invalid Operations without running reset Divide Zero by Zero Scenerio 2
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide a result of 0 with a sign of the Exclusive-OR of the operands’ signs, for an invalid operation of 0/0.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_without_running_reset_Divide_Zero_by_Zero_Scenerio_2_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_without_running_reset_Divide_Zero_by_Zero_Scenerio_2_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide a result of 0 with a sign of the Exclusive-OR of the operands’ signs, for an invalid operation of 0/0.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425906", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_NegZero = -0.0f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_NegZero = -0.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_NegZero = -0.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_NegZero", "-0.0");  
  E_DBGR_VariableCheck("VeTEST_NegZero", -0.0, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_NegZero_Div_NegZero = VeTEST_NegZero / VeTEST_NegZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_NegZero_Div_NegZero = VeTEST_NegZero / VeTEST_NegZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\34");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\34");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_NegZero_Div_NegZero = VeTEST_NegZero / VeTEST_NegZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_NegZero_Div_NegZero value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_NegZero_Div_NegZero value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_NegZero_Div_NegZero is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_NegZero_Div_NegZero",0.0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425907: Verify Invalid Operations without running reset Divide Zero by Zero Scenerio 3
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide a result of 0 with a sign of the Exclusive-OR of the operands’ signs, for an invalid operation of 0/0.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_without_running_reset_Divide_Zero_by_Zero_Scenerio_3_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_without_running_reset_Divide_Zero_by_Zero_Scenerio_3_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide a result of 0 with a sign of the Exclusive-OR of the operands’ signs, for an invalid operation of 0/0.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425907", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_PosZero = 0.0f and VeTEST_NegZero = -0.0f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_PosZero = 0.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_PosZero = 0.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_PosZero", "0.0");  
  E_DBGR_VariableCheck("VeTEST_PosZero", 0.0, Equal);

  snprintf( chActionText, elCount(chActionText), "Set VeTEST_NegZero = -0.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_NegZero = -0.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_NegZero", "-0.0");  
  E_DBGR_VariableCheck("VeTEST_NegZero", -0.0, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_Zero_Div_NegZero = VeTEST_PosZero / VeTEST_NegZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_Zero_Div_NegZero = VeTEST_PosZero / VeTEST_NegZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\35");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\35");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_Zero_Div_NegZero = VeTEST_PosZero / VeTEST_NegZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_Zero_Div_NegZero value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Zero_Div_NegZero value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Zero_Div_NegZero is -0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Zero_Div_NegZero",-0.0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425908: Verify Invalid Operations without running reset Divide Zero by Zero Scenerio 4
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide a result of 0 with a sign of the Exclusive-OR of the operands’ signs, for an invalid operation of 0/0.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_without_running_reset_Divide_Zero_by_Zero_Scenerio_4_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_without_running_reset_Divide_Zero_by_Zero_Scenerio_4_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide a result of 0 with a sign of the Exclusive-OR of the operands’ signs, for an invalid operation of 0/0.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425908", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: VeTEST_NegZero = -0.0f and VeTEST_PosZero = 0.0f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_NegZero = -0.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_NegZero = -0.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_NegZero", "-0.0");  
  E_DBGR_VariableCheck("VeTEST_NegZero", -0.0, Equal);

  snprintf( chActionText, elCount(chActionText), "Set VeTEST_PosZero = 0.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_PosZero = 0.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_PosZero", "0.0");  
  E_DBGR_VariableCheck("VeTEST_PosZero", 0.0, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_Zero_Div_NegZero2 = VeTEST_NegZero / VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_Zero_Div_NegZero2 = VeTEST_NegZero / VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\36");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\36");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_Zero_Div_NegZero2 = VeTEST_NegZero / VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_Zero_Div_NegZero2 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Zero_Div_NegZero2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Zero_Div_NegZero2 is -0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Zero_Div_NegZero2",-0.0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425909: Verify Invalid Operations without running reset Scenerio 1
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured for an invalid operation caused by a direct FLOAT to fixed-point conversion operation or any other conversion operation to a fixed-point value (e.g., ceiling, floor, round, truncate, etc.) that results in a floating-point operation exception, the result shall be modified or limited.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_without_running_reset_Scenerio_1_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_without_running_reset_Scenerio_1_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured for an invalid operation caused by a direct FLOAT to fixed-point conversion operation or any other conversion operation to a fixed-point value (e.g., ceiling, floor, round, truncate, etc.) that results in a floating-point operation exception, the result shall be modified or limited.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425909", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_FloatNeg = -2.9f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatNeg = -2.9f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatNeg = -2.9f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatNeg", "-2.9");  
  E_DBGR_VariableCheck("VeTEST_FloatNeg", -2.9, Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperationsRes7_3 = (LONGWORD)(VeTEST_FloatNeg1);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperationsRes7_3 = (LONGWORD)(VeTEST_FloatNeg1); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\39");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\39");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_InvalidOperationsRes7_3 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes7_3 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes7_3 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes7_3",0.0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set VeTEST_FloatMaxNormPos.myInt = 340.28235E36
  /*******************************************************************************************************************************************************/
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMaxNormPos = 340.28235E36"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMaxNormPos = 340.28235E36"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMaxNormPos", "340.28235E36");  
//  E_DBGR_VariableCheck("VeTEST_FloatMaxNormPos", 340.28235E36, Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 7: Set a breakpoint at "VeTEST_InvalidOperationsRes7 = (LONGWORD)(VeTEST_FloatMaxNormPos.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperationsRes7 = (LONGWORD)(VeTEST_FloatMaxNormPos.myFloat); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\40");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\40");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Verify the VeTEST_InvalidOperationsRes7 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes7 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes7 is 0xFFFFFFFF"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes7",0xFFFFFFFF,Equal);
  A_DBGR_VariableRead("VeTEST_InvalidOperationsRes7",VeTEST_InvalidOperationsRes7_value);
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425910: Verify Invalid Operations without running reset Scenerio 2
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured for an invalid operation caused by a direct FLOAT to fixed-point conversion operation or any other conversion operation to a fixed-point value (e.g., ceiling, floor, round, truncate, etc.) that results in a floating-point operation exception, the result shall be modified or limited.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_without_running_reset_Scenerio_2_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_without_running_reset_Scenerio_2_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured for an invalid operation caused by a direct FLOAT to fixed-point conversion operation or any other conversion operation to a fixed-point value (e.g., ceiling, floor, round, truncate, etc.) that results in a floating-point operation exception, the result shall be modified or limited.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425910", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_FloatMaxNormNeg.myFloat = -340.28235E36
  /*******************************************************************************************************************************************************/
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMaxNormNeg = -340.28235E36"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMaxNormNeg = -340.28235E36"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMaxNormNeg", "-340.28235E36");  
//  E_DBGR_VariableCheck("VeTEST_FloatMaxNormNeg", -340.28235E36, Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperationsRes7_8 = (LONGINT)(VeTEST_FloatMaxNormNeg.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperationsRes7_8 = (LONGINT)(VeTEST_FloatMaxNormNeg.myFloat); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\41");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\41");
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperationsRes7_8 = (LONGINT)(VeTEST_FloatMaxNormNeg.myFloat); inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_InvalidOperationsRes7_8 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes7_8 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes7_8 is 0x80000000"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes7_8",0x80000000,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set VeTEST_FloatMaxNormPos.myFloat = 340.28235E36
  /*******************************************************************************************************************************************************/
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMaxNormPos = 340.28235E36"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMaxNormPos = 340.28235E36"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMaxNormPos", "340.28235E36");  
//  E_DBGR_VariableCheck("VeTEST_FloatMaxNormPos", 340.28235E36, Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 7: Set a breakpoint at "VeTEST_InvalidOperationsRes7_4 = (LONGINT)(VeTEST_FloatMaxNormPos.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperationsRes7_4 = (LONGINT)(VeTEST_FloatMaxNormPos.myFloat); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\42");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\42");
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperationsRes7_4 = (LONGINT)(VeTEST_FloatMaxNormPos.myFloat); inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Verify the VeTEST_InvalidOperationsRes7_4 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes7_4 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes7_4 is 0x7FFFFFFF"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes7_4",0x7FFFFFFF,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Verify the VeTEST_FloatCvrt_ftoiz_MaxPos value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MaxPos value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MaxPos is -1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MaxPos",-1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the VeTEST_FloatCvrt_ftoiz_PosInf value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_PosInf value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_PosInf is -1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_PosInf",-1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Verify the VeTEST_InvalidOperationsRes1 value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes1 value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes1 is INF"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes1",INF,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 12: Verify the VeTEST_InvalidOperationsRes2 value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes2 value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes2 is NAN"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes2",-NAN,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 13: Verify the VeTEST_InvalidOperationsRes3 value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes3 value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes3 is NAN"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes3",NAN,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Verify the VeTEST_InvalidOperationsRes4 value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes4 value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes4 is NAN"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes4",NAN,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the VeTEST_InvalidOperationsRes5 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes5 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes5 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperationsRes1",VeTEST_InvalidOperations_value_INF);
  A_DBGR_VariableRead("VeTEST_InvalidOperationsRes2",VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("VeTEST_InvalidOperationsRes3",VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("VeTEST_InvalidOperationsRes4",VeTEST_InvalidOperations_value_NAN);  
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes5",0.0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 16: Verify the VeTEST_InvalidOperationsRes5_2 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes5_2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes5_2 is 1.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes5_2",1.0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 17: Verify the VeTEST_InvalidOperationsRes6 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes6 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes6 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes6",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 18: Verify the VeTEST_InvalidOperationsRes7 value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes7 value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes7 is 0xFFFFFFFF"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes7",0xFFFFFFFF,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 19: Verify the VeTEST_InvalidOperationsRes8 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes8 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes8 is 13.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperationsRes7",VeTEST_InvalidOperationsRes7_value);
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes8",13.0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 20: Verify the VeTEST_InvalidOperationsRes8_2 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes8_2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes8_2 is 13.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes8_2",13.0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 21: Verify the VeTEST_InvalidOperationsRes9 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes9 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes9 is -1.4012985e-45"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes9",-1.4012985e-45,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 22: Verify the VeTEST_InvalidOperationsRes11 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes11 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes11 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes11",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 23: Verify the VeTEST_InvalidOperationsRes12 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes12 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "-VeTEST_InvalidOperationsRes12 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes12",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 24: Verify the VeTEST_Constant_1 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_1 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_1 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Constant_1",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 25: Verify the VeTEST_Constant_2 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_2 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Constant_2",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 26: Verify the VeTEST_Constant_3 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_3 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_3 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Constant_3",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 27: Verify the VeTEST_Constant_4 value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_4 value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_4 is INF"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_Constant_4",INF,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 28: Verify the VeTEST_Constant_5 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_5 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_5 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_Constant_4",VeTEST_InvalidOperations_value_INF);
  E_DBGR_VariableCheck("VeTEST_Constant_5",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 29: Verify the VeTEST_Constant_6 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_6 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_6 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Constant_6",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 30: Verify the VeTEST_Constant_7 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_7 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_7 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Constant_7",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 31: Verify the VeTEST_Constant_8 value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_8 value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_8 is INF"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_Constant_8",INF,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 32: Verify the VeTEST_Constant_9 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_9 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_9 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_Constant_8",VeTEST_InvalidOperations_value_INF);
  E_DBGR_VariableCheck("VeTEST_Constant_9",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 33: Verify the VeTEST_Constant_10 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_10 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_10 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Constant_10",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 34: Verify the VeTEST_Constant_11 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_11 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_11 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Constant_11",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 35: Verify the VeTEST_Constant_12 value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_12 value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_12 is INF"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_Constant_12",INF,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 36: Verify the VeTEST_Constant_13 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_13 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_13 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_Constant_12",VeTEST_InvalidOperations_value_INF);
  E_DBGR_VariableCheck("VeTEST_Constant_13",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 37: Verify the VeTEST_Constant_14 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_14 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_14 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Constant_14",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 38: Verify the VeTEST_Constant_15 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_15 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_15 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Constant_15",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 39: Verify the VeTEST_Constant_16 value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_16 value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_16 is INF"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_Constant_16",INF,Equal);
  
//  /*******************************************************************************************************************************************************/    
//    // Test Step 40: Verify the VeTEST_FloatCvrt_ftouz_MinPos value
//  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MinPos value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MinPos is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_Constant_16",VeTEST_InvalidOperations_value_INF);
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MinPos",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 41: Verify the VeTEST_FloatCvrt_ftouz_Pos value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_Pos value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_Pos is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_Pos",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 42: Verify the VeTEST_FloatCvrt_ftouz_Pos_1 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = 12456.890f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = 12456.890f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "12456.890");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",12456.890,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_Pos_1 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_Pos_1 is 12456"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_Pos_1",12456,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 43: Verify the VeTEST_FloatCvrt_ftouz_Pos_2 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = 54321.987f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = 54321.987f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "54321.987");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",54321.987,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_Pos_2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_Pos_2 is 54321"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_Pos_2",54321,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 44: Verify the VeTEST_FloatCvrt_ftouz_Pos_3 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = 35263.123f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = 35263.123f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "35263.123");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",35263.123,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_Pos_3 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_Pos_3 is 35263"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_Pos_3",35263,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 45: Verify the VeTEST_FloatCvrt_ftouz_MaxPos value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MaxPos value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MaxPos is 65535"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MaxPos",65535,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 46: Verify the VeTEST_FloatCvrt_ftouz_MinNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MinNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MinNeg is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MinNeg",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 47: Verify the VeTEST_FloatCvrt_ftouz_MaxPosL value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MaxPosL value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MaxPosL is 4294967295"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MaxPosL",4294967295,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 48: Verify the VeTEST_FloatCvrt_ftouz_MaxPosL1 value
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = 35263.123f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = 35263.123f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "35263.123");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",35263.123,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MaxPosL1 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MaxPosL1 is 35263"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_FloatCvrt_ftouz_MaxPosL",VeTEST_FloatCvrt_ftouz_MaxPosL_value);
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MaxPosL1",35263,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 49: Verify the VeTEST_FloatCvrt_ftouz_MinNegL value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MinNegL value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MinNegL is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MinNegL",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 50: Verify the VeTEST_FloatCvrt_ftouz_Neg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_Neg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_Neg is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_Neg",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 51: Verify the VeTEST_FloatCvrt_ftouz_MaxNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MaxNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MaxNeg is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MaxNeg",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 52: Verify the VeTEST_FloatCvrt_ftouz_PosInf value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_PosInf value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_PosInf is 65535"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_PosInf",65535,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 53: Verify the VeTEST_FloatCvrt_ftouz_Neginf value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_Neginf value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_Neginf is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_Neginf",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 54: Verify the VeTEST_FloatCvrt_ftouz_PosNaN value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_PosNaN value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_PosNaN is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_PosNaN",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 55: Verify the VeTEST_FloatCvrt_ftouz_NegNaN value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_NegNaN value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_NegNaN is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_NegNaN",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 56: Verify the VeTEST_FloatCvrt_ftoiz_MinPos value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MinPos value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MinPos is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MinPos",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 57: Verify the VeTEST_FloatCvrt_ftoiz_Pos value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Pos value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Pos is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Pos",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 58: Verify the VeTEST_FloatCvrt_ftoiz_MaxPos value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MaxPos value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MaxPos is -1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MaxPos",-1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 59: Verify the VeTEST_FloatCvrt_ftoiz_MaxPosL value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MaxPosL value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MaxPosL is 2147483647"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MaxPosL",2147483647,Equal);
  
    /*******************************************************************************************************************************************************/    
    // Test Step 60: Verify the VeTEST_FloatCvrt_ftoiz_MaxPosL1 value
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = 31263.123f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = 31263.123f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "31263.123");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",31263.123,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MaxPosL1 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MaxPosL1 is 31263"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MaxPosL1",31263,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 61: Verify the VeTEST_FloatCvrt_ftoiz_MinNegL value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MinNegL value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MinNegL is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MinNegL",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 62: Verify the VeTEST_FloatCvrt_ftoiz_MinNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MinNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MinNeg is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MinNeg",0,Equal);
  
    /*******************************************************************************************************************************************************/    
    // Test Step 63: Verify the VeTEST_FloatCvrt_ftoiz_Neg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Neg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Neg is -1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Neg",-1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 64: Verify the VeTEST_FloatCvrt_ftoiz_Neg_1 value
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = -12456.890f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = -12456.890f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "-12456.890");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",-12456.890,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Neg_1 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Neg_1 is -12456"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Neg_1",-12456,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 65: Verify the VeTEST_FloatCvrt_ftoiz_Neg_L1 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Neg_L1 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Neg_L1 is -12456"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Neg_L1",-12456,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 66: Verify the VeTEST_FloatCvrt_ftoiz_Neg_2 value
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = -24321.987f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = -24321.987f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "-24321.987");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",-24321.987,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Neg_2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Neg_2 is -24321"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Neg_2",-24321,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 67: Verify the VeTEST_FloatCvrt_ftoiz_Neg_L2 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Neg_L2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Neg_L2 is -24321"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Neg_L2",-24321,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 68: Verify the VeTEST_FloatCvrt_ftoiz_Neg_3 value
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = -15263.123f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = -15263.123f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "-15263.123");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",-15263.123,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Neg_3 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Neg_3 is -15263"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Neg_3",-15263,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 69: Verify the VeTEST_FloatCvrt_ftoiz_Neg_L3 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Neg_L3 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Neg_L3 is -15263"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Neg_L3",-15263,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 70: Verify the VeTEST_FloatCvrt_ftoiz_MaxNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MaxNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MaxNeg is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MaxNeg",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 71: Verify the VeTEST_FloatCvrt_ftoiz_PosInf value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_PosInf value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_PosInf is -1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_PosInf",-1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 72: Verify the VeTEST_FloatCvrt_ftoiz_Neginf value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Neginf value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Neginf is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Neginf",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 73: Verify the VeTEST_FloatCvrt_ftoiz_PosNaN value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_PosNaN value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_PosNaN is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_PosNaN",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 74: Verify the VeTEST_FloatCvrt_ftoiz_NegNaN value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_NegNaN value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_NegNaN is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_NegNaN",0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645507: Verify Divide by Zero Scenerio 1
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of a division by zero exception.

***************************************************************************************************/
testcase Testcase_Verify_Divide_by_Zero_Scenerio_1_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Divide_by_Zero_Scenerio_1_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of a division by zero exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645507", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_DivByZeroNum = 5.0f and VeTEST_PosZero = 0.0f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_DivByZeroNum = 5.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_DivByZeroNum = 5.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_DivByZeroNum", "5.0");  
  E_DBGR_VariableCheck("VeTEST_DivByZeroNum", 5.0, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_PosZero = 0.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_PosZero = 0.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_PosZero", "0.0");
  E_DBGR_VariableCheck("VeTEST_PosZero", 0.0, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_DivideByPosZero = VeTEST_DivByZeroNum / VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_DivideByPosZero = VeTEST_DivByZeroNum / VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\10");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\10");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_DivideByPosZero = VeTEST_DivByZeroNum / VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_DivideByPosZero value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_DivideByPosZero value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_DivideByPosZero is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_DivideByPosZero",340.28235E36,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645508: Verify Divide by Zero Scenerio 2
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of a division by zero exception.

***************************************************************************************************/
testcase Testcase_Verify_Divide_by_Zero_Scenerio_2_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Divide_by_Zero_Scenerio_2_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of a division by zero exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645508", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_DivByZeroNum = 5.0f and VeTEST_NegZero = -0.0f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_DivByZeroNum = 5.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_DivByZeroNum = 5.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_DivByZeroNum", "5.0");  
  E_DBGR_VariableCheck("VeTEST_DivByZeroNum", 5.0, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_NegZero = -0.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_NegZero = -0.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_NegZero", "-0.0");
  E_DBGR_VariableCheck("VeTEST_NegZero", -0.0, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_DivideByNegZero = VeTEST_DivByZeroNum / VeTEST_NegZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_DivideByNegZero = VeTEST_DivByZeroNum / VeTEST_NegZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_DivideByNegZero = VeTEST_DivByZeroNum / VeTEST_NegZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_DivideByNegZero  value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_DivideByNegZero  value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_DivideByNegZero is -340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_DivideByNegZero",-340.28235E36,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645509: Verify Divide by Zero Scenerio 3
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of a division by zero exception.

***************************************************************************************************/
testcase Testcase_Verify_Divide_by_Zero_Scenerio_3_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Divide_by_Zero_Scenerio_3_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of a division by zero exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645509", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: VeTEST_FloatPos_1 = 2.8 and VeTEST_PosZero = 0.0
  /*******************************************************************************************************************************************************/
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_1 = 2.8f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_1 = 2.8f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_1", "2.8");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_1", 2.8, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_PosZero = 0.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_PosZero = 0.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_PosZero", "0.0");
  E_DBGR_VariableCheck("VeTEST_PosZero", 0.0, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_DivideByPosZero_1 = VeTEST_FloatPos_1 / VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_DivideByPosZero_1 = VeTEST_FloatPos_1 / VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\12");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\12");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_DivideByPosZero_1 = VeTEST_FloatPos_1 / VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_DivideByPosZero_1 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_DivideByPosZero_1 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_DivideByPosZero_1 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_DivideByPosZero_1",340.28235E36,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645510: Round Towards Zero Scenerio 1
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to set the rounding mode to round toward zero.

***************************************************************************************************/
testcase Testcase_Verify_Round_Towards_Zero_Scenerio_1_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Round_Towards_Zero_Scenerio_1_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to set the rounding mode to round toward zero.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645510", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_FloatPos = 2.8f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos = 2.8f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos = 2.8f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos", "2.8");  
  E_DBGR_VariableCheck("VeTEST_FloatPos", 2.8, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_FloatCvtPos = (LONGWORD)(VeTEST_FloatPos);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_FloatCvtPos = (LONGWORD)(VeTEST_FloatPos); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\15");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\15");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_FloatCvtPos = (LONGWORD)(VeTEST_FloatPos); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_FloatCvtPos  value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvtPos  value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvtPos is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvtPos ",2,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645511: Verify Round Towards Zero Scenerio 2
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to set the rounding mode to round toward zero.

***************************************************************************************************/
testcase Testcase_Verify_Round_Towards_Zero_Scenerio_2_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Round_Towards_Zero_Scenerio_2_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to set the rounding mode to round toward zero.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645511", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_FloatNeg = -1.9f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatNeg = -1.9f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatNeg = -1.9f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatNeg", "-1.9");  
  E_DBGR_VariableCheck("VeTEST_FloatNeg", -1.9, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_FloatCvtNeg = (LONGWORD)(VeTEST_FloatNeg);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_FloatCvtNeg = (LONGWORD)(VeTEST_FloatNeg); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\16");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\16");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_FloatCvtNeg = (LONGWORD)(VeTEST_FloatNeg); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_FloatCvtNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvtNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvtNeg is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvtNeg",0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645512: Verify Round Towards Zero Scenerio 3
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to set the rounding mode to round toward zero.

***************************************************************************************************/
testcase Testcase_Verify_Round_Towards_Zero_Scenerio_3_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Round_Towards_Zero_Scenerio_3_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to set the rounding mode to round toward zero.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645512", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_FloatNeg = -1.9f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatNeg = -1.9f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatNeg = -1.9f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatNeg", "-1.9");  
  E_DBGR_VariableCheck("VeTEST_FloatNeg", -1.9, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_FloatCvtNeg2 = (INTEGER)(VeTEST_FloatNeg);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_FloatCvtNeg2 = (INTEGER)(VeTEST_FloatNeg); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\17");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\17");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_FloatCvtNeg2 = (INTEGER)(VeTEST_FloatNeg); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_FloatCvtNeg2 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvtNeg2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvtNeg2 is -1.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvtNeg2",-1.0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645513: Verify Inexact Exception Scenerio 1
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to take no action upon occurrence of an inexact exception.

***************************************************************************************************/
testcase Testcase_Verify_Inexact_Exception_Scenerio_1_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Inexact_Exception_Scenerio_1_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to take no action upon occurrence of an inexact exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645513", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3:Set VeTEST_FloatNum = 2.0f and VeTEST_FloatDen = 3.0f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatNum = 2.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatNum = 2.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatNum", "2.0");  
  E_DBGR_VariableCheck("VeTEST_FloatNum", 2.0, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatDen = 3.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatDen = 3.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatDen", "3.0");
  E_DBGR_VariableCheck("VeTEST_FloatDen", 3.0, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InexactResult = VeTEST_FloatNum/VeTEST_FloatDen;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InexactResult = VeTEST_FloatNum/VeTEST_FloatDen; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\20");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\20");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InexactResult = VeTEST_FloatNum/VeTEST_FloatDen; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_InexactResult value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InexactResult value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InexactResult is 0.66666663"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InexactResult",0.66666663,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645514: Verify Inexact Exception Scenerio 2
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to take no action upon occurrence of an inexact exception.

***************************************************************************************************/
testcase Testcase_Verify_Inexact_Exception_Scenerio_2_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Inexact_Exception_Scenerio_2_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to take no action upon occurrence of an inexact exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645514", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_FloatNum_1 = 4.0f and VeTEST_FloatDen_1 = 7.0f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatNum_1 = 4.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatNum_1 = 4.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatNum_1", "4.0");  
  E_DBGR_VariableCheck("VeTEST_FloatNum_1", 4.0, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatDen_1 = 7.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatDen_1 = 7.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatDen_1", "7.0");
  E_DBGR_VariableCheck("VeTEST_FloatDen_1", 7.0, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InexactResult_1 = VeTEST_FloatNum_1/VeTEST_FloatDen_1;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InexactResult_1 = VeTEST_FloatNum_1/VeTEST_FloatDen_1; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\21");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\21");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InexactResult_1 = VeTEST_FloatNum_1/VeTEST_FloatDen_1; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_InexactResult_1 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InexactResult_1 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InexactResult_1 is 0.57142854"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InexactResult_1",0.57142854,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645515: Verify Underflow Scenerio 1
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide a result of 0 with the sign of the intermediate result, upon the occurrence of an underflow exception.

***************************************************************************************************/
testcase Testcase_Verify_Underflow_Scenerio_1_Core1() 
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Underflow_Scenerio_1_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide a result of 0 with the sign of the intermediate result, upon the occurrence of an underflow exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645515", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3:Set Set VeTEST_FloatMinNormPos.myFloat = 1.17549435E-38
  /*******************************************************************************************************************************************************/
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMinNormPos.myFloat = 0x00800000"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMinNormPos.myFloat = 0x00800000"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMinNormPos.myFloat", "0x00800000");  
//  E_DBGR_VariableCheck("VeTEST_FloatMinNormPos.myFloat", 0x00800000, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_UnderflowMin_x_Min = VeTEST_FloatMinNormPos.myFloat * VeTEST_FloatMinNormPos.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_UnderflowMin_x_Min = VeTEST_FloatMinNormPos.myFloat * VeTEST_FloatMinNormPos.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\24");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\24");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_UnderflowMin_x_Min = VeTEST_FloatMinNormPos.myFloat * VeTEST_FloatMinNormPos.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_UnderflowMin_x_Min value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_UnderflowMin_x_Min value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_UnderflowMin_x_Min is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_UnderflowMin_x_Min",0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645516: Verify Underflow Scenerio 2
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide a result of 0 with the sign of the intermediate result, upon the occurrence of an underflow exception.

***************************************************************************************************/
testcase Testcase_Verify_Underflow_Scenerio_2_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Underflow_Scenerio_2_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide a result of 0 with the sign of the intermediate result, upon the occurrence of an underflow exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645516", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set Set VeTEST_FloatMinNormPos.myFloat = 1.17549435E-38 and VeTEST_FloatMinNormNeg.myFloat = -1.17549435E-38
  /*******************************************************************************************************************************************************/
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMinNormPos = 1.17549435E-38"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMinNormPos = 1.17549435E-38"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMinNormPos", "1.17549435E-38");  
//  E_DBGR_VariableCheck("VeTEST_FloatMinNormPos", 1.17549435E-38, Equal);
  
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMinNormNeg = -1.17549435E-38"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMinNormNeg = -1.17549435E-38"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMinNormNeg", "-1.17549435E-38");
//  E_DBGR_VariableCheck("VeTEST_FloatMinNormNeg", -1.17549435E-38, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_UnderflowMin_Div_MinNeg = VeTEST_FloatMinNormPos.myFloat / VeTEST_FloatMinNormNeg.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_UnderflowMin_Div_MinNeg = VeTEST_FloatMinNormPos.myFloat / VeTEST_FloatMinNormNeg.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\25");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\25");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_UnderflowMin_Div_MinNeg = VeTEST_FloatMinNormPos.myFloat / VeTEST_FloatMinNormNeg.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_UnderflowMin_Div_MinNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_UnderflowMin_Div_MinNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_UnderflowMin_Div_MinNeg is -1.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_UnderflowMin_Div_MinNeg",-1.0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645517: Verify Underflow Scenerio 3
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide a result of 0 with the sign of the intermediate result, upon the occurrence of an underflow exception.

***************************************************************************************************/
testcase Testcase_Verify_Underflow_Scenerio_3_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Underflow_Scenerio_3_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide a result of 0 with the sign of the intermediate result, upon the occurrence of an underflow exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645517", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set Set VeTEST_FloatMinNormPos.myFloat = 1.17549435E-38 and VeTEST_FloatMinNormNeg.myFloat = -1.17549435E-38
  /*******************************************************************************************************************************************************/
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMinNormPos = 1.17549435E-38"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMinNormPos = 1.17549435E-38"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMinNormPos", "1.17549435E-38");  
//  E_DBGR_VariableCheck("VeTEST_FloatMinNormPos", 1.17549435E-38, Equal);
  
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMinNormNeg = -1.17549435E-38"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMinNormNeg = -1.17549435E-38"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMinNormNeg", "-1.17549435E-38");
//  E_DBGR_VariableCheck("VeTEST_FloatMinNormNeg", -1.17549435E-38, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_UnderflowMin_Div_MinNeg = VeTEST_FloatMinNormPos.myFloat / VeTEST_FloatMinNormNeg.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_UnderflowMin_Div_MinNeg = VeTEST_FloatMinNormPos.myFloat / VeTEST_FloatMinNormNeg.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\25");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\25");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_UnderflowMin_Div_MinNeg = VeTEST_FloatMinNormPos.myFloat / VeTEST_FloatMinNormNeg.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_UnderflowMin_Div_MinNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_UnderflowMin_Div_MinNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_UnderflowMin_Div_MinNeg is -1.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_UnderflowMin_Div_MinNeg",-1.0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645518: Verify Overflow Scenerio Scenerio 1
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide a result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of an overflow exception.

***************************************************************************************************/
testcase Testcase_Verify_Overflow_Scenerio_1_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Overflow_Scenerio_1_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide a result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of an overflow exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645518", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_FloatMaxNormPos.myFloat = 340.28235E36
  /*******************************************************************************************************************************************************/
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMaxNormPos = 340.28235E36"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMaxNormPos = 340.28235E36"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMaxNormPos", "340.28235E36");  
//  E_DBGR_VariableCheck("VeTEST_FloatMaxNormPos", 340.28235E36, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_OverflowMax_x_Max = VeTEST_FloatMaxNormPos.myFloat * VeTEST_FloatMaxNormPos.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_OverflowMax_x_Max = VeTEST_FloatMaxNormPos.myFloat * VeTEST_FloatMaxNormPos.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\29");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\29");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_OverflowMax_x_Max = VeTEST_FloatMaxNormPos.myFloat * VeTEST_FloatMaxNormPos.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_OverflowMax_x_Max value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_OverflowMax_x_Max value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_OverflowMax_x_Max is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_OverflowMax_x_Max",340.28235E36,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645519: Verify Overflow Scenerio 2
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide a result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of an overflow exception.

***************************************************************************************************/
testcase Testcase_Verify_Overflow_Scenerio_2_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Overflow_Scenerio_2_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide a result of the format’s largest finite number with the sign of the intermediate result, upon the occurrence of an overflow exception.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645519", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_FloatMaxNormPos.myFloat = 340.28235E36 and VeTEST_FloatMaxNormNeg.myFloat = -340.28235E36 in watch window
  /*******************************************************************************************************************************************************/
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMaxNormPos = 340.28235E36"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMaxNormPos = 340.28235E36"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMaxNormPos", "340.28235E36");  
//  E_DBGR_VariableCheck("VeTEST_FloatMaxNormPos", 340.28235E36, Equal);
  
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMaxNormNeg = -340.28235E38"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMaxNormNeg = -340.28235E38"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMaxNormNeg", "-340.28235E38");
//  E_DBGR_VariableCheck("VeTEST_FloatMaxNormNeg", -340.28235E38, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_OverflowMax_x_MaxNeg = VeTEST_FloatMaxNormPos.myFloat * VeTEST_FloatMaxNormNeg.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_OverflowMax_x_MaxNeg = VeTEST_FloatMaxNormPos.myFloat * VeTEST_FloatMaxNormNeg.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\30");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\30");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_OverflowMax_x_MaxNeg = VeTEST_FloatMaxNormPos.myFloat * VeTEST_FloatMaxNormNeg.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_OverflowMax_x_MaxNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_OverflowMax_x_MaxNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_OverflowMax_x_MaxNeg is -340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_OverflowMax_x_MaxNeg",-340.28235E36,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645520: Verify Invalid Operations without running reset Divide Zero by Zero Scenerio 1
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide a result of 0 with a sign of the Exclusive-OR of the operands’ signs, for an invalid operation of 0/0.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_without_running_reset_Divide_Zero_by_Zero_Scenerio_1_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_without_running_reset_Divide_Zero_by_Zero_Scenerio_1_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide a result of 0 with a sign of the Exclusive-OR of the operands’ signs, for an invalid operation of 0/0.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645520", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_PosZero = 0.0f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_PosZero = 0.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_PosZero = 0.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_PosZero", "0.0");  
  E_DBGR_VariableCheck("VeTEST_PosZero", 0.0, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_Zero_Div_Zero = VeTEST_PosZero / VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_Zero_Div_Zero = VeTEST_PosZero / VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\33");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\33");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_Zero_Div_Zero = VeTEST_PosZero / VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_Zero_Div_Zero value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Zero_Div_Zero value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Zero_Div_Zero is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Zero_Div_Zero",0.0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645521: Verify Invalid Operations without running reset Divide Zero by Zero Scenerio 2
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide a result of 0 with a sign of the Exclusive-OR of the operands’ signs, for an invalid operation of 0/0.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_without_running_reset_Divide_Zero_by_Zero_Scenerio_2_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_without_running_reset_Divide_Zero_by_Zero_Scenerio_2_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide a result of 0 with a sign of the Exclusive-OR of the operands’ signs, for an invalid operation of 0/0.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645521", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_NegZero = -0.0f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_NegZero = -0.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_NegZero = -0.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_NegZero", "-0.0");  
  E_DBGR_VariableCheck("VeTEST_NegZero", -0.0, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_NegZero_Div_NegZero = VeTEST_NegZero / VeTEST_NegZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_NegZero_Div_NegZero = VeTEST_NegZero / VeTEST_NegZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\34");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\34");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_NegZero_Div_NegZero = VeTEST_NegZero / VeTEST_NegZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_NegZero_Div_NegZero value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_NegZero_Div_NegZero value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_NegZero_Div_NegZero is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_NegZero_Div_NegZero",0.0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645522: Verify Invalid Operations without running reset Divide Zero by Zero Scenerio 3
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide a result of 0 with a sign of the Exclusive-OR of the operands’ signs, for an invalid operation of 0/0.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_without_running_reset_Divide_Zero_by_Zero_Scenerio_3_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_without_running_reset_Divide_Zero_by_Zero_Scenerio_3_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide a result of 0 with a sign of the Exclusive-OR of the operands’ signs, for an invalid operation of 0/0.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645522", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_PosZero = 0.0f and VeTEST_NegZero = -0.0f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_PosZero = 0.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_PosZero = 0.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_PosZero", "0.0");  
  E_DBGR_VariableCheck("VeTEST_PosZero", 0.0, Equal);

  snprintf( chActionText, elCount(chActionText), "Set VeTEST_NegZero = -0.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_NegZero = -0.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_NegZero", "-0.0");  
  E_DBGR_VariableCheck("VeTEST_NegZero", -0.0, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_Zero_Div_NegZero = VeTEST_PosZero / VeTEST_NegZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_Zero_Div_NegZero = VeTEST_PosZero / VeTEST_NegZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\35");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\35");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_Zero_Div_NegZero = VeTEST_PosZero / VeTEST_NegZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_Zero_Div_NegZero value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Zero_Div_NegZero value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Zero_Div_NegZero is -0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Zero_Div_NegZero",-0.0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645523: Verify Invalid Operations without running reset Divide Zero by Zero Scenerio 4
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured to provide a result of 0 with a sign of the Exclusive-OR of the operands’ signs, for an invalid operation of 0/0.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_without_running_reset_Divide_Zero_by_Zero_Scenerio_4_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_without_running_reset_Divide_Zero_by_Zero_Scenerio_4_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured to provide a result of 0 with a sign of the Exclusive-OR of the operands’ signs, for an invalid operation of 0/0.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645523", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: VeTEST_NegZero = -0.0f and VeTEST_PosZero = 0.0f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_NegZero = -0.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_NegZero = -0.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_NegZero", "-0.0");  
  E_DBGR_VariableCheck("VeTEST_NegZero", -0.0, Equal);

  snprintf( chActionText, elCount(chActionText), "Set VeTEST_PosZero = 0.0f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_PosZero = 0.0f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_PosZero", "0.0");  
  E_DBGR_VariableCheck("VeTEST_PosZero", 0.0, Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_Zero_Div_NegZero2 = VeTEST_NegZero / VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_Zero_Div_NegZero2 = VeTEST_NegZero / VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\36");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\36");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_Zero_Div_NegZero2 = VeTEST_NegZero / VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_Zero_Div_NegZero2 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Zero_Div_NegZero2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Zero_Div_NegZero2 is -0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Zero_Div_NegZero2",-0.0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645524: Verify Invalid Operations without running reset Scenerio 1
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured for an invalid operation caused by a direct FLOAT to fixed-point conversion operation or any other conversion operation to a fixed-point value (e.g., ceiling, floor, round, truncate, etc.) that results in a floating-point operation exception, the result shall be modified or limited.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_without_running_reset_Scenerio_1_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_without_running_reset_Scenerio_1_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured for an invalid operation caused by a direct FLOAT to fixed-point conversion operation or any other conversion operation to a fixed-point value (e.g., ceiling, floor, round, truncate, etc.) that results in a floating-point operation exception, the result shall be modified or limited.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645524", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_FloatNeg = -2.9f
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatNeg = -2.9f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatNeg = -2.9f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatNeg", "-2.9");  
  E_DBGR_VariableCheck("VeTEST_FloatNeg", -2.9, Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperationsRes7_3 = (LONGWORD)(VeTEST_FloatNeg1);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperationsRes7_3 = (LONGWORD)(VeTEST_FloatNeg1); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\39");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\39");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_InvalidOperationsRes7_3 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes7_3 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes7_3 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes7_3",0.0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set VeTEST_FloatMaxNormPos.myInt = 340.28235E36
  /*******************************************************************************************************************************************************/
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMaxNormPos = 340.28235E36"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMaxNormPos = 340.28235E36"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMaxNormPos", "340.28235E36");  
//  E_DBGR_VariableCheck("VeTEST_FloatMaxNormPos", 340.28235E36, Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 7: Set a breakpoint at "VeTEST_InvalidOperationsRes7 = (LONGWORD)(VeTEST_FloatMaxNormPos.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperationsRes7 = (LONGWORD)(VeTEST_FloatMaxNormPos.myFloat); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\40");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\40");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Verify the VeTEST_InvalidOperationsRes7 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes7 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes7 is 0xFFFFFFFF"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes7",0xFFFFFFFF,Equal);
  A_DBGR_VariableRead("VeTEST_InvalidOperationsRes7",VeTEST_InvalidOperationsRes7_value);
  A_DBGR_BreakpointSet("Test_Float");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float");
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36645525: Verify Invalid Operations without running reset Scenerio 2
----------------------------------------------------------------------------------------------------
Description:   Verify the software shall be configured for an invalid operation caused by a direct FLOAT to fixed-point conversion operation or any other conversion operation to a fixed-point value (e.g., ceiling, floor, round, truncate, etc.) that results in a floating-point operation exception, the result shall be modified or limited.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_without_running_reset_Scenerio_2_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_without_running_reset_Scenerio_2_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:Verify the software shall be configured for an invalid operation caused by a direct FLOAT to fixed-point conversion operation or any other conversion operation to a fixed-point value (e.g., ceiling, floor, round, truncate, etc.) that results in a floating-point operation exception, the result shall be modified or limited.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36645525", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Flash the Software and ECU is running"); 
  snprintf( chExpectedText, elCount(chExpectedText), "ECU should be in running state"); 
  TestStepAddActionExpected( chActionText, chExpectedText );

  A_DBGR_BreakpointDeleteAll();
  A_DBGR_RnGo();
  E_DBGR_CheckState(T32_State_Running);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Set a breakpoint at coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Set VeTEST_FloatMaxNormNeg.myFloat = -340.28235E36
  /*******************************************************************************************************************************************************/
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMaxNormNeg = -340.28235E36"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMaxNormNeg = -340.28235E36"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMaxNormNeg", "-340.28235E36");  
//  E_DBGR_VariableCheck("VeTEST_FloatMaxNormNeg", -340.28235E36, Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperationsRes7_8 = (LONGINT)(VeTEST_FloatMaxNormNeg.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperationsRes7_8 = (LONGINT)(VeTEST_FloatMaxNormNeg.myFloat); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\41");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\41");
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperationsRes7_8 = (LONGINT)(VeTEST_FloatMaxNormNeg.myFloat); inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Verify the VeTEST_InvalidOperationsRes7_8 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes7_8 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes7_8 is 0x80000000"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes7_8",0x80000000,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set VeTEST_FloatMaxNormPos.myFloat = 340.28235E36
  /*******************************************************************************************************************************************************/
//  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatMaxNormPos = 340.28235E36"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatMaxNormPos = 340.28235E36"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  A_DBGR_VariableSet("VeTEST_FloatMaxNormPos", "340.28235E36");  
//  E_DBGR_VariableCheck("VeTEST_FloatMaxNormPos", 340.28235E36, Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 7: Set a breakpoint at "VeTEST_InvalidOperationsRes7_4 = (LONGINT)(VeTEST_FloatMaxNormPos.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperationsRes7_4 = (LONGINT)(VeTEST_FloatMaxNormPos.myFloat); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\42");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\42");
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperationsRes7_4 = (LONGINT)(VeTEST_FloatMaxNormPos.myFloat); inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Verify the VeTEST_InvalidOperationsRes7_4 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes7_4 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes7_4 is 0x7FFFFFFF"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes7_4",0x7FFFFFFF,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Verify the VeTEST_FloatCvrt_ftoiz_MaxPos value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MaxPos value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MaxPos is -1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MaxPos",-1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the VeTEST_FloatCvrt_ftoiz_PosInf value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_PosInf value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_PosInf is -1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_PosInf",-1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Verify the VeTEST_InvalidOperationsRes1 value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes1 value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes1 is INF"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes1",INF,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 12: Verify the VeTEST_InvalidOperationsRes2 value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes2 value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes2 is NAN"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes2",-NAN,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 13: Verify the VeTEST_InvalidOperationsRes3 value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes3 value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes3 is NAN"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes3",NAN,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Verify the VeTEST_InvalidOperationsRes4 value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes4 value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes4 is NAN"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes4",NAN,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the VeTEST_InvalidOperationsRes5 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes5 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes5 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperationsRes1",VeTEST_InvalidOperations_value_INF);
  A_DBGR_VariableRead("VeTEST_InvalidOperationsRes2",VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("VeTEST_InvalidOperationsRes3",VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("VeTEST_InvalidOperationsRes4",VeTEST_InvalidOperations_value_NAN);  
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes5",0.0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 16: Verify the VeTEST_InvalidOperationsRes5_2 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes5_2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes5_2 is 1.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes5_2",1.0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 17: Verify the VeTEST_InvalidOperationsRes6 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes6 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes6 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes6",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 18: Verify the VeTEST_InvalidOperationsRes7 value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes7 value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes7 is 0xFFFFFFFF"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes7",0xFFFFFFFF,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 19: Verify the VeTEST_InvalidOperationsRes8 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes8 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes8 is 13.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperationsRes7",VeTEST_InvalidOperationsRes7_value);
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes8",13.0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 20: Verify the VeTEST_InvalidOperationsRes8_2 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes8_2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes8_2 is 13.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes8_2",13.0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 21: Verify the VeTEST_InvalidOperationsRes9 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes9 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes9 is -1.4012985e-45"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes9",-1.4012985e-45,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 22: Verify the VeTEST_InvalidOperationsRes11 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes11 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperationsRes11 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes11",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 23: Verify the VeTEST_InvalidOperationsRes12 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperationsRes12 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "-VeTEST_InvalidOperationsRes12 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperationsRes12",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 24: Verify the VeTEST_Constant_1 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_1 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_1 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Constant_1",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 25: Verify the VeTEST_Constant_2 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_2 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Constant_2",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 26: Verify the VeTEST_Constant_3 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_3 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_3 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Constant_3",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 27: Verify the VeTEST_Constant_4 value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_4 value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_4 is INF"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_Constant_4",INF,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 28: Verify the VeTEST_Constant_5 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_5 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_5 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_Constant_4",VeTEST_InvalidOperations_value_INF);
  E_DBGR_VariableCheck("VeTEST_Constant_5",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 29: Verify the VeTEST_Constant_6 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_6 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_6 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Constant_6",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 30: Verify the VeTEST_Constant_7 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_7 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_7 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Constant_7",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 31: Verify the VeTEST_Constant_8 value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_8 value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_8 is INF"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_Constant_8",INF,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 32: Verify the VeTEST_Constant_9 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_9 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_9 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_Constant_8",VeTEST_InvalidOperations_value_INF);
  E_DBGR_VariableCheck("VeTEST_Constant_9",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 33: Verify the VeTEST_Constant_10 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_10 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_10 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Constant_10",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 34: Verify the VeTEST_Constant_11 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_11 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_11 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Constant_11",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 35: Verify the VeTEST_Constant_12 value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_12 value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_12 is INF"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_Constant_12",INF,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 36: Verify the VeTEST_Constant_13 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_13 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_13 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_Constant_12",VeTEST_InvalidOperations_value_INF);
  E_DBGR_VariableCheck("VeTEST_Constant_13",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 37: Verify the VeTEST_Constant_14 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_14 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_14 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Constant_14",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 38: Verify the VeTEST_Constant_15 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_15 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_15 is 340.28235E36"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_Constant_15",340.28235E36,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 39: Verify the VeTEST_Constant_16 value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_Constant_16 value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_Constant_16 is INF"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_Constant_16",INF,Equal);
  
//  /*******************************************************************************************************************************************************/    
//    // Test Step 40: Verify the VeTEST_FloatCvrt_ftouz_MinPos value
//  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MinPos value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MinPos is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_Constant_16",VeTEST_InvalidOperations_value_INF);
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MinPos",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 41: Verify the VeTEST_FloatCvrt_ftouz_Pos value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_Pos value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_Pos is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_Pos",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 42: Verify the VeTEST_FloatCvrt_ftouz_Pos_1 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = 12456.890f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = 12456.890f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "12456.890");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",12456.890,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_Pos_1 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_Pos_1 is 12456"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_Pos_1",12456,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 43: Verify the VeTEST_FloatCvrt_ftouz_Pos_2 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = 54321.987f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = 54321.987f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "54321.987");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",54321.987,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_Pos_2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_Pos_2 is 54321"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_Pos_2",54321,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 44: Verify the VeTEST_FloatCvrt_ftouz_Pos_3 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = 35263.123f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = 35263.123f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "35263.123");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",35263.123,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_Pos_3 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_Pos_3 is 35263"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_Pos_3",35263,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 45: Verify the VeTEST_FloatCvrt_ftouz_MaxPos value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MaxPos value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MaxPos is 65535"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MaxPos",65535,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 46: Verify the VeTEST_FloatCvrt_ftouz_MinNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MinNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MinNeg is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MinNeg",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 47: Verify the VeTEST_FloatCvrt_ftouz_MaxPosL value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MaxPosL value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MaxPosL is 4294967295"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MaxPosL",4294967295,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 48: Verify the VeTEST_FloatCvrt_ftouz_MaxPosL1 value
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = 35263.123f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = 35263.123f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "35263.123");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",35263.123,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MaxPosL1 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MaxPosL1 is 35263"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_FloatCvrt_ftouz_MaxPosL",VeTEST_FloatCvrt_ftouz_MaxPosL_value);
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MaxPosL1",35263,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 49: Verify the VeTEST_FloatCvrt_ftouz_MinNegL value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MinNegL value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MinNegL is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MinNegL",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 50: Verify the VeTEST_FloatCvrt_ftouz_Neg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_Neg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_Neg is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_Neg",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 51: Verify the VeTEST_FloatCvrt_ftouz_MaxNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MaxNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MaxNeg is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MaxNeg",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 52: Verify the VeTEST_FloatCvrt_ftouz_PosInf value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_PosInf value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_PosInf is 65535"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_PosInf",65535,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 53: Verify the VeTEST_FloatCvrt_ftouz_Neginf value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_Neginf value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_Neginf is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_Neginf",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 54: Verify the VeTEST_FloatCvrt_ftouz_PosNaN value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_PosNaN value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_PosNaN is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_PosNaN",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 55: Verify the VeTEST_FloatCvrt_ftouz_NegNaN value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_NegNaN value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_NegNaN is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_NegNaN",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 56: Verify the VeTEST_FloatCvrt_ftoiz_MinPos value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MinPos value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MinPos is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MinPos",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 57: Verify the VeTEST_FloatCvrt_ftoiz_Pos value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Pos value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Pos is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Pos",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 58: Verify the VeTEST_FloatCvrt_ftoiz_MaxPos value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MaxPos value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MaxPos is -1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MaxPos",-1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 59: Verify the VeTEST_FloatCvrt_ftoiz_MaxPosL value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MaxPosL value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MaxPosL is 2147483647"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MaxPosL",2147483647,Equal);
  
    /*******************************************************************************************************************************************************/    
    // Test Step 60: Verify the VeTEST_FloatCvrt_ftoiz_MaxPosL1 value
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = 31263.123f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = 31263.123f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "31263.123");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",31263.123,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MaxPosL1 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MaxPosL1 is 31263"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MaxPosL1",31263,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 61: Verify the VeTEST_FloatCvrt_ftoiz_MinNegL value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MinNegL value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MinNegL is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MinNegL",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 62: Verify the VeTEST_FloatCvrt_ftoiz_MinNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MinNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MinNeg is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MinNeg",0,Equal);
  
    /*******************************************************************************************************************************************************/    
    // Test Step 63: Verify the VeTEST_FloatCvrt_ftoiz_Neg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Neg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Neg is -1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Neg",-1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 64: Verify the VeTEST_FloatCvrt_ftoiz_Neg_1 value
