  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\25");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\25");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 12: Set a breakpoint at "VeTEST_InvalidOperations5 = VeTEST_PINF.myFloat + VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 5"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 5"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "5");  
  E_DBGR_VariableCheck("testflag", 5, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations5 = VeTEST_PINF.myFloat + VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\29");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\29");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 13: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724357: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined SUB Core 1
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_SUB_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_SUB_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724357", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core1_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core1_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core1_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);    

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations6 = VeTEST_FloatSignalingNan.myFloat - VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 6"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 6"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "6");  
  E_DBGR_VariableCheck("testflag", 6, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations6 = VeTEST_FloatSignalingNan.myFloat - VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\33");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\33");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 

  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations7 = VeTEST_aINF.myFloat - VeTEST_bINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 7"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 7"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "7");  
  E_DBGR_VariableCheck("testflag", 7, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations7 = VeTEST_aINF.myFloat - VeTEST_bINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\37");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\37");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 12: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 13: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at "VeTEST_InvalidOperations8 = VeTEST_cINF.myFloat - VeTEST_dINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 8"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 8"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "8");  
  E_DBGR_VariableCheck("testflag", 8, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations8 = VeTEST_cINF.myFloat - VeTEST_dINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\41");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\41");   

  /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724363: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined MUL Core 1
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_MUL_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_MUL_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724363", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core1_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core1_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core1_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);    
 
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations9 = VeTEST_FloatSignalingNan.myFloat * VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 9"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 9"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","9");  
  E_DBGR_VariableCheck("testflag",9,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations9 = VeTEST_FloatSignalingNan.myFloat * VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\45");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\45"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations10 = VeTEST_PINF.myFloat * VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 10"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 10"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","10");  
  E_DBGR_VariableCheck("testflag",10,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations10 = VeTEST_PINF.myFloat * VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\49");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\49");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");  

  /*******************************************************************************************************************************************************/    
    // Test Step 12: Set a breakpoint at "VeTEST_InvalidOperations11 = VeTEST_NINF.myFloat * VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 11"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 11"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","11");  
  E_DBGR_VariableCheck("testflag",11,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations11 = VeTEST_NINF.myFloat * VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\53");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\53");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 13: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724369: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined DIV Core 1
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_DIV_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_DIV_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724369", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core1_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core1_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core1_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);    
 
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations12 = VeTEST_FloatSignalingNan.myFloat / VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 12"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 12"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","12");  
  E_DBGR_VariableCheck("testflag",12,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations12 = VeTEST_FloatSignalingNan.myFloat / VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\57");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\57");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations13 = VeTEST_PINF.myFloat / VeTEST_PINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 13"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 13"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","13");  
  E_DBGR_VariableCheck("testflag",13,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations13 = VeTEST_PINF.myFloat / VeTEST_PINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\61");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\61");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 11: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 12: Set a breakpoint at "VeTEST_InvalidOperations14 = VeTEST_PINF.myFloat / VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 14"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 14"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","14");  
  E_DBGR_VariableCheck("testflag",14,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations14 = VeTEST_PINF.myFloat / VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\65");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\65");   

  /*******************************************************************************************************************************************************/    
    // Test Step 13: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
   
  /*******************************************************************************************************************************************************/    
    // Test Step 15: Set a breakpoint at "VeTEST_InvalidOperations15 = VeTEST_NINF.myFloat/ VeTEST_PINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 15"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 15"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","15");  
  E_DBGR_VariableCheck("testflag",15,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations15 = VeTEST_NINF.myFloat/ VeTEST_PINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\69");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\69"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 16: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 17: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 18: Set a breakpoint at "VeTEST_InvalidOperations16 = VeTEST_NINF.myFloat/ VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 16"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 16"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","16");  
  E_DBGR_VariableCheck("testflag",16,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations16 = VeTEST_NINF.myFloat/ VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_BreakpointSet("Test_Float\\73");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\73");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 19: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 4"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",4,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 20: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 21: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 5"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",5,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724375: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined CMP Core 1
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_CMP_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_CMP_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724375", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core1_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core1_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core1_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);    
 
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations17 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatPos);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 17"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 17"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","17");  
  E_DBGR_VariableCheck("testflag",17,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations17 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatPos); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\77");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\77");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations18 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatDenorm1.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 18"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 18"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","18");  
  E_DBGR_VariableCheck("testflag",18,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations18 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatDenorm1.myFloat); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\81");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\81");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 12: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 13: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at "VeTEST_InvalidOperations19 = (VeTEST_FloatDenorm2.myFloat == VeTEST_FloatSignalingNan.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 19"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 19"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","19");  
  E_DBGR_VariableCheck("testflag",19,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations19 = (VeTEST_FloatDenorm2.myFloat == VeTEST_FloatSignalingNan.myFloat); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\85");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\85");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 16: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 17: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 18: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 19: Set a breakpoint at "VeTEST_InvalidOperations20 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatSignalingNan.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 20"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 20"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","20");  
  E_DBGR_VariableCheck("testflag",20,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations20 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatSignalingNan.myFloat); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\89");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\89");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 20: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 21: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 22: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 23: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 24: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",4,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724340: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined x/NaN Core 2
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_x_NaN_Core2()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_x_NaN_Core2" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724340", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core2_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core2_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core2_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",2,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations1 = VeTEST_DivByZeroNum / VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 1"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "1");  
  E_DBGR_VariableCheck("testflag", 1, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations1 = VeTEST_DivByZeroNum / VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\13");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\13"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal); 
 
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");   

  /*******************************************************************************************************************************************************/    
    // Test Step 9: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);  
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724346: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined FLOAT to fixed point conversions Core 2
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_FLOAT_Core2()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_FLOAT_Core2" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724346", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core2_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core2_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core2_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",2,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations2 = (LONGWORD) VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 2"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "2");  
  E_DBGR_VariableCheck("testflag", 2, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations2 = (LONGWORD) VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\17");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\17");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");   

  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations3 = (LONGINT) VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 3"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_VariableSet("testflag", "3");  
  E_DBGR_VariableCheck("testflag", 3, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations3 = (LONGINT) VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\21");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\21");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/
   
  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 12: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 13: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724352: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined ADD Core 2
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_ADD_Core2()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_ADD_Core2" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724352", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
/*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core2_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core2_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core2_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",2,Equal);    
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations4 = VeTEST_FloatSignalingNan.myFloat + VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 4"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 4"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "4");  
  E_DBGR_VariableCheck("testflag", 4, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations4 = VeTEST_FloatSignalingNan.myFloat + VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\25");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\25");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 12: Set a breakpoint at "VeTEST_InvalidOperations5 = VeTEST_PINF.myFloat + VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 5"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 5"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "5");  
  E_DBGR_VariableCheck("testflag", 5, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations5 = VeTEST_PINF.myFloat + VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\29");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\29");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 13: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724358: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined SUB Core 2
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_SUB_Core2()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_SUB_Core2" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724358", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core2_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core2_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core2_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",2,Equal);    

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations6 = VeTEST_FloatSignalingNan.myFloat - VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 6"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 6"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "6");  
  E_DBGR_VariableCheck("testflag", 6, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations6 = VeTEST_FloatSignalingNan.myFloat - VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\33");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\33");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 

  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations7 = VeTEST_aINF.myFloat - VeTEST_bINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 7"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 7"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "7");  
  E_DBGR_VariableCheck("testflag", 7, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations7 = VeTEST_aINF.myFloat - VeTEST_bINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\37");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\37");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 12: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 13: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at "VeTEST_InvalidOperations8 = VeTEST_cINF.myFloat - VeTEST_dINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 8"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 8"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "8");  
  E_DBGR_VariableCheck("testflag", 8, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations8 = VeTEST_cINF.myFloat - VeTEST_dINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\41");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\41");   

  /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724364: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined MUL Core 2
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_MUL_Core2()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_MUL_Core2" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724364", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core2_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core2_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core2_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",2,Equal);    
 
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations9 = VeTEST_FloatSignalingNan.myFloat * VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 9"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 9"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","9");  
  E_DBGR_VariableCheck("testflag",9,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations9 = VeTEST_FloatSignalingNan.myFloat * VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\45");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\45"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations10 = VeTEST_PINF.myFloat * VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 10"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 10"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","10");  
  E_DBGR_VariableCheck("testflag",10,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations10 = VeTEST_PINF.myFloat * VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\49");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\49");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");  

  /*******************************************************************************************************************************************************/    
    // Test Step 12: Set a breakpoint at "VeTEST_InvalidOperations11 = VeTEST_NINF.myFloat * VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 11"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 11"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","11");  
  E_DBGR_VariableCheck("testflag",11,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations11 = VeTEST_NINF.myFloat * VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\53");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\53");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 13: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724370: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined DIV Core 2
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_DIV_Core2()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_DIV_Core2" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724370", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core2_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core2_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core2_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",2,Equal);    
 
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations12 = VeTEST_FloatSignalingNan.myFloat / VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 12"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 12"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","12");  
  E_DBGR_VariableCheck("testflag",12,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations12 = VeTEST_FloatSignalingNan.myFloat / VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\57");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\57");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations13 = VeTEST_PINF.myFloat / VeTEST_PINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 13"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 13"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","13");  
  E_DBGR_VariableCheck("testflag",13,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations13 = VeTEST_PINF.myFloat / VeTEST_PINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\61");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\61");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 11: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 12: Set a breakpoint at "VeTEST_InvalidOperations14 = VeTEST_PINF.myFloat / VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 14"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 14"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","14");  
  E_DBGR_VariableCheck("testflag",14,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations14 = VeTEST_PINF.myFloat / VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\65");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\65");   

  /*******************************************************************************************************************************************************/    
    // Test Step 13: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
   
  /*******************************************************************************************************************************************************/    
    // Test Step 15: Set a breakpoint at "VeTEST_InvalidOperations15 = VeTEST_NINF.myFloat/ VeTEST_PINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 15"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 15"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","15");  
  E_DBGR_VariableCheck("testflag",15,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations15 = VeTEST_NINF.myFloat/ VeTEST_PINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\69");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\69"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 16: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 17: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 18: Set a breakpoint at "VeTEST_InvalidOperations16 = VeTEST_NINF.myFloat/ VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 16"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 16"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","16");  
  E_DBGR_VariableCheck("testflag",16,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations16 = VeTEST_NINF.myFloat/ VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_BreakpointSet("Test_Float\\73");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\73");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 19: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 4"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",4,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 20: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 21: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 5"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",5,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724376: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined CMP Core 2
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_CMP_Core2()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_CMP_Core2" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724376", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core2_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core2_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core2_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",2,Equal);    
 
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations17 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatPos);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 17"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 17"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","17");  
  E_DBGR_VariableCheck("testflag",17,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations17 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatPos); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\77");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\77");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations18 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatDenorm1.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 18"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 18"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","18");  
  E_DBGR_VariableCheck("testflag",18,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations18 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatDenorm1.myFloat); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\81");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\81");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 12: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 13: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at "VeTEST_InvalidOperations19 = (VeTEST_FloatDenorm2.myFloat == VeTEST_FloatSignalingNan.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 19"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 19"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","19");  
  E_DBGR_VariableCheck("testflag",19,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations19 = (VeTEST_FloatDenorm2.myFloat == VeTEST_FloatSignalingNan.myFloat); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\85");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\85");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 16: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 17: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 18: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 19: Set a breakpoint at "VeTEST_InvalidOperations20 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatSignalingNan.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 20"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 20"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","20");  
  E_DBGR_VariableCheck("testflag",20,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations20 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatSignalingNan.myFloat); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\89");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\89");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 20: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 21: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 22: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 23: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 24: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",4,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724341: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined x/NaN Core 3
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_x_NaN_Core3()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_x_NaN_Core3" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724341", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core3_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core3_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core3_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",3,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations1 = VeTEST_DivByZeroNum / VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 1"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "1");  
  E_DBGR_VariableCheck("testflag", 1, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations1 = VeTEST_DivByZeroNum / VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\13");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\13"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal); 
 
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");   

  /*******************************************************************************************************************************************************/    
    // Test Step 9: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);  
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724347: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined FLOAT to fixed point conversions Core 3
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_FLOAT_Core3()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_FLOAT_Core3" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724347", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core3_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core3_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core3_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",3,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations2 = (LONGWORD) VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 2"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "2");  
  E_DBGR_VariableCheck("testflag", 2, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations2 = (LONGWORD) VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\17");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\17");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");   

  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations3 = (LONGINT) VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 3"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_VariableSet("testflag", "3");  
  E_DBGR_VariableCheck("testflag", 3, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations3 = (LONGINT) VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\21");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\21");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/
   
  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 12: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 13: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724353: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined ADD Core 3
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_ADD_Core3()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_ADD_Core3" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724353", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
/*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core3_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core3_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core3_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",3,Equal);    
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations4 = VeTEST_FloatSignalingNan.myFloat + VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 4"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 4"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "4");  
  E_DBGR_VariableCheck("testflag", 4, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations4 = VeTEST_FloatSignalingNan.myFloat + VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\25");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\25");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 12: Set a breakpoint at "VeTEST_InvalidOperations5 = VeTEST_PINF.myFloat + VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 5"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 5"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "5");  
  E_DBGR_VariableCheck("testflag", 5, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations5 = VeTEST_PINF.myFloat + VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\29");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\29");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 13: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724359: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined SUB Core 3
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_SUB_Core3()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_SUB_Core3" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724359", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core3_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core3_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core3_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",3,Equal);    

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations6 = VeTEST_FloatSignalingNan.myFloat - VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 6"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 6"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "6");  
  E_DBGR_VariableCheck("testflag", 6, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations6 = VeTEST_FloatSignalingNan.myFloat - VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\33");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\33");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 

  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations7 = VeTEST_aINF.myFloat - VeTEST_bINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 7"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 7"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "7");  
  E_DBGR_VariableCheck("testflag", 7, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations7 = VeTEST_aINF.myFloat - VeTEST_bINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\37");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\37");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 12: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 13: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at "VeTEST_InvalidOperations8 = VeTEST_cINF.myFloat - VeTEST_dINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 8"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 8"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "8");  
  E_DBGR_VariableCheck("testflag", 8, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations8 = VeTEST_cINF.myFloat - VeTEST_dINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\41");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\41");   

  /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724365: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined MUL Core 3
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_MUL_Core3()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_MUL_Core3" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724365", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core3_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core3_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core3_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",3,Equal);    
 
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations9 = VeTEST_FloatSignalingNan.myFloat * VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 9"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 9"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","9");  
  E_DBGR_VariableCheck("testflag",9,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations9 = VeTEST_FloatSignalingNan.myFloat * VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\45");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\45"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations10 = VeTEST_PINF.myFloat * VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 10"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 10"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","10");  
  E_DBGR_VariableCheck("testflag",10,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations10 = VeTEST_PINF.myFloat * VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\49");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\49");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");  

  /*******************************************************************************************************************************************************/    
    // Test Step 12: Set a breakpoint at "VeTEST_InvalidOperations11 = VeTEST_NINF.myFloat * VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 11"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 11"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","11");  
  E_DBGR_VariableCheck("testflag",11,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations11 = VeTEST_NINF.myFloat * VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\53");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\53");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 13: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724371: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined DIV Core 3
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_DIV_Core3()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_DIV_Core3" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724371", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core3_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core3_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core3_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",3,Equal);    
 
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations12 = VeTEST_FloatSignalingNan.myFloat / VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 12"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 12"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","12");  
  E_DBGR_VariableCheck("testflag",12,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations12 = VeTEST_FloatSignalingNan.myFloat / VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\57");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\57");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations13 = VeTEST_PINF.myFloat / VeTEST_PINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 13"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 13"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","13");  
  E_DBGR_VariableCheck("testflag",13,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations13 = VeTEST_PINF.myFloat / VeTEST_PINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\61");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\61");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 11: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 12: Set a breakpoint at "VeTEST_InvalidOperations14 = VeTEST_PINF.myFloat / VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 14"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 14"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","14");  
  E_DBGR_VariableCheck("testflag",14,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations14 = VeTEST_PINF.myFloat / VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\65");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\65");   

  /*******************************************************************************************************************************************************/    
    // Test Step 13: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
   
  /*******************************************************************************************************************************************************/    
    // Test Step 15: Set a breakpoint at "VeTEST_InvalidOperations15 = VeTEST_NINF.myFloat/ VeTEST_PINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 15"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 15"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","15");  
  E_DBGR_VariableCheck("testflag",15,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations15 = VeTEST_NINF.myFloat/ VeTEST_PINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\69");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\69"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 16: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 17: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 18: Set a breakpoint at "VeTEST_InvalidOperations16 = VeTEST_NINF.myFloat/ VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 16"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 16"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","16");  
  E_DBGR_VariableCheck("testflag",16,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations16 = VeTEST_NINF.myFloat/ VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_BreakpointSet("Test_Float\\73");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\73");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 19: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 4"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",4,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 20: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 21: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 5"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",5,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724377: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined CMP Core 3
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_CMP_Core3()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_CMP_Core3" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724377", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core3_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core3_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core3_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",3,Equal);    
 
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations17 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatPos);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 17"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 17"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","17");  
  E_DBGR_VariableCheck("testflag",17,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations17 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatPos); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\77");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\77");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations18 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatDenorm1.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 18"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 18"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","18");  
  E_DBGR_VariableCheck("testflag",18,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations18 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatDenorm1.myFloat); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\81");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\81");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 12: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 13: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at "VeTEST_InvalidOperations19 = (VeTEST_FloatDenorm2.myFloat == VeTEST_FloatSignalingNan.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 19"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 19"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","19");  
  E_DBGR_VariableCheck("testflag",19,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations19 = (VeTEST_FloatDenorm2.myFloat == VeTEST_FloatSignalingNan.myFloat); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\85");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\85");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 16: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 17: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 18: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 19: Set a breakpoint at "VeTEST_InvalidOperations20 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatSignalingNan.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 20"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 20"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","20");  
  E_DBGR_VariableCheck("testflag",20,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations20 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatSignalingNan.myFloat); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\89");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\89");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 20: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 21: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 22: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 23: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 24: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",4,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724342: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined x/NaN Core 4
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_x_NaN_Core4()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_x_NaN_Core4" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724342", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core4 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core4_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core4_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core4_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core4 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core4 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core4","1");
  E_DBGR_VariableCheck("FPU_Core4",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 4"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",4,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations1 = VeTEST_DivByZeroNum / VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 1"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "1");  
  E_DBGR_VariableCheck("testflag", 1, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations1 = VeTEST_DivByZeroNum / VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\13");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\13");    
 
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Configure FPU_Core4 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core4 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core4 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core4","1");
  E_DBGR_VariableCheck("FPU_Core4",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
   
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);  
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724348: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined FLOAT to fixed point conversions Core 4
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_FLOAT_Core4()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_FLOAT_Core4" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724348", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core4 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core4_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core4_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core4_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core4 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core4 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core4","1");
  E_DBGR_VariableCheck("FPU_Core4",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 4"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",4,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations2 = (LONGWORD) VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 2"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "2");  
  E_DBGR_VariableCheck("testflag", 2, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations2 = (LONGWORD) VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\17");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\17");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Configure FPU_Core4 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core4 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core4 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core4","1");
  E_DBGR_VariableCheck("FPU_Core4",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");   
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core4 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core4 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core4","1");
  E_DBGR_VariableCheck("FPU_Core4",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 10: Set a breakpoint at "VeTEST_InvalidOperations3 = (LONGINT) VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 3"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("testflag", "3");  
  E_DBGR_VariableCheck("testflag", 3, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations3 = (LONGINT) VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\21");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\21");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 12: Configure FPU_Core4 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core4 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core4 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core4","1");
  E_DBGR_VariableCheck("FPU_Core4",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 13: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724354: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined ADD Core 4
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_ADD_Core4()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_ADD_Core4" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724354", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
/*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core4 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core4_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core4_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core4_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core4 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core4 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core4","1");
  E_DBGR_VariableCheck("FPU_Core4",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 4"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",4,Equal);    
  
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations4 = VeTEST_FloatSignalingNan.myFloat + VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 4"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 4"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "4");  
  E_DBGR_VariableCheck("testflag", 4, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations4 = VeTEST_FloatSignalingNan.myFloat + VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\25");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\25");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core4 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core4 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core4 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core4","1");
  E_DBGR_VariableCheck("FPU_Core4",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Configure FPU_Core4 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core4 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core4 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core4","1");
  E_DBGR_VariableCheck("FPU_Core4",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 12: Set a breakpoint at "VeTEST_InvalidOperations5 = VeTEST_PINF.myFloat + VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 5"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 5"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "5");  
  E_DBGR_VariableCheck("testflag", 5, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations5 = VeTEST_PINF.myFloat + VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\29");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\29");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 13: Configure FPU_Core4 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core4 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core4 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core4","1");
  E_DBGR_VariableCheck("FPU_Core4",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724360: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined SUB Core 4
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_SUB_Core4()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_SUB_Core4" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724360", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core4 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core4_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core4_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core4_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core4 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core4 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core4","1");
  E_DBGR_VariableCheck("FPU_Core4",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 4"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",4,Equal);    

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations6 = VeTEST_FloatSignalingNan.myFloat - VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 6"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 6"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "6");  
  E_DBGR_VariableCheck("testflag", 6, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations6 = VeTEST_FloatSignalingNan.myFloat - VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\33");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\33");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core4 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core4 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core4 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core4","1");
  E_DBGR_VariableCheck("FPU_Core4",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 

  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations7 = VeTEST_aINF.myFloat - VeTEST_bINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 7"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 7"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "7");  
  E_DBGR_VariableCheck("testflag", 7, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations7 = VeTEST_aINF.myFloat - VeTEST_bINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\37");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\37");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 12: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 13: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at "VeTEST_InvalidOperations8 = VeTEST_cINF.myFloat - VeTEST_dINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 8"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 8"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "8");  
  E_DBGR_VariableCheck("testflag", 8, Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations8 = VeTEST_cINF.myFloat - VeTEST_dINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\41");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\41");   

  /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724366: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined MUL Core 4
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_MUL_Core4()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_MUL_Core4" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724366", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core4 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core4_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core4_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core4_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core4 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core4 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("FPU_Core4","1");
  E_DBGR_VariableCheck("FPU_Core4",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 4"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",4,Equal);    
 
  /*******************************************************************************************************************************************************/    
    // Test Step 4: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at "VeTEST_InvalidOperations9 = VeTEST_FloatSignalingNan.myFloat * VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set testflag = 9"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 9"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","9");  
  E_DBGR_VariableCheck("testflag",9,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations9 = VeTEST_FloatSignalingNan.myFloat * VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\45");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\45"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the resetinfo.ResetSrc value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the resetinfo.ResetSrc value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "resetinfo.ResetSrc is 31"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  E_DBGR_VariableCheck("resetinfo.ResetSrc",31,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Configure FPU_Core4 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core4 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core4 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableSet("FPU_Core4","1");
  E_DBGR_VariableCheck("FPU_Core4",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations10 = VeTEST_PINF.myFloat * VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 10"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 10"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","10");  
  E_DBGR_VariableCheck("testflag",10,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations10 = VeTEST_PINF.myFloat * VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\49");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\49");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");  

  /*******************************************************************************************************************************************************/    
    // Test Step 12: Set a breakpoint at "VeTEST_InvalidOperations11 = VeTEST_NINF.myFloat * VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 11"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 11"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","11");  
  E_DBGR_VariableCheck("testflag",11,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations11 = VeTEST_NINF.myFloat * VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\53");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\53");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 13: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("resetinfo.ResetSrc",ResetSrc_value);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36724372: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET not defined DIV Core 4
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_DIV_Core4()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_not_defined_DIV_Core4" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36724372", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core4 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core4_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core4_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core4_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core4 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core4 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core4","1");
  E_DBGR_VariableCheck("FPU_Core4",1,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the coreId
