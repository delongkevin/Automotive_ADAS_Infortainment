  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = 54321.987f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = 54321.987f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "54321.987");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",54321.987,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_Pos_2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_Pos_2 is 54321"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_Pos_2",54321,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 44: Verify the VeTEST_FloatCvrt_ftouz_Pos_3 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = 35263.123f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = 35263.123f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "35263.123");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",35263.123,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_Pos_3 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_Pos_3 is 35263"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_Pos_3",35263,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 45: Verify the VeTEST_FloatCvrt_ftouz_MaxPos value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MaxPos value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MaxPos is 65535"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MaxPos",65535,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 46: Verify the VeTEST_FloatCvrt_ftouz_MinNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MinNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MinNeg is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MinNeg",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 47: Verify the VeTEST_FloatCvrt_ftouz_MaxPosL value
  /*******************************************************************************************************************************************************/

//  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MaxPosL value"); 
//  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MaxPosL is 4294967295"); 
//  TestStepAddActionExpected( chActionText, chExpectedText );
//  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MaxPosL",4294967295,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 48: Verify the VeTEST_FloatCvrt_ftouz_MaxPosL1 value
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = 35263.123f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = 35263.123f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "35263.123");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",35263.123,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MaxPosL1 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MaxPosL1 is 35263"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_FloatCvrt_ftouz_MaxPosL",VeTEST_FloatCvrt_ftouz_MaxPosL_value);
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MaxPosL1",35263,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 49: Verify the VeTEST_FloatCvrt_ftouz_MinNegL value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MinNegL value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MinNegL is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MinNegL",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 50: Verify the VeTEST_FloatCvrt_ftouz_Neg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_Neg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_Neg is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_Neg",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 51: Verify the VeTEST_FloatCvrt_ftouz_MaxNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_MaxNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_MaxNeg is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_MaxNeg",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 52: Verify the VeTEST_FloatCvrt_ftouz_PosInf value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_PosInf value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_PosInf is 65535"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_PosInf",65535,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 53: Verify the VeTEST_FloatCvrt_ftouz_Neginf value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_Neginf value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_Neginf is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_Neginf",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 54: Verify the VeTEST_FloatCvrt_ftouz_PosNaN value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_PosNaN value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_PosNaN is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_PosNaN",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 55: Verify the VeTEST_FloatCvrt_ftouz_NegNaN value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftouz_NegNaN value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftouz_NegNaN is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftouz_NegNaN",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 56: Verify the VeTEST_FloatCvrt_ftoiz_MinPos value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MinPos value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MinPos is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MinPos",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 57: Verify the VeTEST_FloatCvrt_ftoiz_Pos value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Pos value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Pos is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Pos",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 58: Verify the VeTEST_FloatCvrt_ftoiz_MaxPos value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MaxPos value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MaxPos is -1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MaxPos",-1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 59: Verify the VeTEST_FloatCvrt_ftoiz_MaxPosL value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MaxPosL value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MaxPosL is 2147483647"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MaxPosL",2147483647,Equal);
  
    /*******************************************************************************************************************************************************/    
    // Test Step 60: Verify the VeTEST_FloatCvrt_ftoiz_MaxPosL1 value
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = 31263.123f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = 31263.123f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "31263.123");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",31263.123,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MaxPosL1 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MaxPosL1 is 31263"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MaxPosL1",31263,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 61: Verify the VeTEST_FloatCvrt_ftoiz_MinNegL value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MinNegL value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MinNegL is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MinNegL",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 62: Verify the VeTEST_FloatCvrt_ftoiz_MinNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MinNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MinNeg is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MinNeg",0,Equal);
  
    /*******************************************************************************************************************************************************/    
    // Test Step 63: Verify the VeTEST_FloatCvrt_ftoiz_Neg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Neg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Neg is -1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Neg",-1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 64: Verify the VeTEST_FloatCvrt_ftoiz_Neg_1 value
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = -12456.890f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = -12456.890f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "-12456.890");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",-12456.890,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Neg_1 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Neg_1 is -12456"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Neg_1",-12456,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 65: Verify the VeTEST_FloatCvrt_ftoiz_Neg_L1 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Neg_L1 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Neg_L1 is -12456"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Neg_L1",-12456,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 66: Verify the VeTEST_FloatCvrt_ftoiz_Neg_2 value
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = -24321.987f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = -24321.987f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "-24321.987");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",-24321.987,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Neg_2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Neg_2 is -24321"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Neg_2",-24321,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 67: Verify the VeTEST_FloatCvrt_ftoiz_Neg_L2 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Neg_L2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Neg_L2 is -24321"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Neg_L2",-24321,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 68: Verify the VeTEST_FloatCvrt_ftoiz_Neg_3 value
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set VeTEST_FloatPos_2 = -15263.123f"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatPos_2 = -15263.123f"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("VeTEST_FloatPos_2", "-15263.123");  
  E_DBGR_VariableCheck("VeTEST_FloatPos_2",-15263.123,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Neg_3 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Neg_3 is -15263"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Neg_3",-15263,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 69: Verify the VeTEST_FloatCvrt_ftoiz_Neg_L3 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Neg_L3 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Neg_L3 is -15263"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Neg_L3",-15263,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 70: Verify the VeTEST_FloatCvrt_ftoiz_MaxNeg value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_MaxNeg value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_MaxNeg is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_MaxNeg",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 71: Verify the VeTEST_FloatCvrt_ftoiz_PosInf value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_PosInf value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_PosInf is -1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_PosInf",-1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 72: Verify the VeTEST_FloatCvrt_ftoiz_Neginf value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_Neginf value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_Neginf is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_Neginf",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 73: Verify the VeTEST_FloatCvrt_ftoiz_PosNaN value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_PosNaN value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_PosNaN is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_PosNaN",0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 74: Verify the VeTEST_FloatCvrt_ftoiz_NegNaN value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_FloatCvrt_ftoiz_NegNaN value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_FloatCvrt_ftoiz_NegNaN is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_FloatCvrt_ftoiz_NegNaN",0,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36425917: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined x/NaN Core 0
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_x_NaN_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_x_NaN_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36425917", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core0 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core0_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core0_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core0_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations1 = VeTEST_DivByZeroNum / VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 1"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "1");  
  E_DBGR_VariableCheck("testflag", 1, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations1 = VeTEST_DivByZeroNum / VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\13");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\13");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at test_exc_address = GetHWIO_Ptr_FP_Exception(coreId); inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at test_exc_address = GetHWIO_Ptr_FP_Exception(coreId);; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at test_exc_cnt = GetHWIO_Cnt_FP_Exceptions(coreId); inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
   
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at test_exc_cnt = GetHWIO_Cnt_FP_Exceptions(coreId); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\7");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\7");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations1, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations1",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations1 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686915: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined FLOAT to fixed point conversions Core 0
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_FLOAT_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_FLOAT_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686915", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core0 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core0_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core0_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core0_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations2 = (LONGWORD) VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 2"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "2");  
  E_DBGR_VariableCheck("testflag", 2, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations2 = (LONGWORD) VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\17");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\17");   
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
   
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the VeTEST_InvalidOperations2 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations2 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperations2",0.0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 7: Set a breakpoint at "VeTEST_InvalidOperations3 = (LONGINT) VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
 
  snprintf( chActionText, elCount(chActionText), "Set testflag = 3"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "3");  
  E_DBGR_VariableCheck("testflag", 3, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations3 = (LONGINT) VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\21");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\21");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Verify the VeTEST_InvalidOperations3 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations3 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations3 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_VariableCheck("VeTEST_InvalidOperations3",0.0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686921: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined ADD Core 0
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_ADD_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_ADD_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686921", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core0 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core0_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core0_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core0_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations4 = VeTEST_FloatSignalingNan.myFloat + VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 4"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 4"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "4");  
  E_DBGR_VariableCheck("testflag", 4, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations4 = VeTEST_FloatSignalingNan.myFloat + VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\25");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\25");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");   

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at "VeTEST_InvalidOperations5 = VeTEST_PINF.myFloat + VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 5"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 5"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "5");  
  E_DBGR_VariableCheck("testflag", 5, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations5 = VeTEST_PINF.myFloat + VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\29");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\29");  
    
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations4, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations4",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations4 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations5",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations5 = %ld", VeTEST_InvalidOperations_value_NAN);  
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);   
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686927: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined SUB Core 0
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_SUB_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_SUB_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686927", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core0 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core0_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core0_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core0_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations6 = VeTEST_FloatSignalingNan.myFloat - VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 6"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 6"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "6");  
  E_DBGR_VariableCheck("testflag", 6, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations6 = VeTEST_FloatSignalingNan.myFloat - VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\33");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\33");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");    

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at "VeTEST_InvalidOperations7 = VeTEST_aINF.myFloat - VeTEST_bINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 7"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 7"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "7");  
  E_DBGR_VariableCheck("testflag", 7, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations7 = VeTEST_aINF.myFloat - VeTEST_bINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\37");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\37");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations6, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations6",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations6 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations8 = VeTEST_cINF.myFloat - VeTEST_dINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 8"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 8"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "8");  
  E_DBGR_VariableCheck("testflag", 8, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations8 = VeTEST_cINF.myFloat - VeTEST_dINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\41");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\41");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the VeTEST_InvalidOperations7, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations7",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations7 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
    
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Verify the VeTEST_InvalidOperations8, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations8",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations8 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686935: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined MUL Core 0
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_MUL_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_MUL_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686935", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core0 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core0_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core0_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core0_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations9 = VeTEST_FloatSignalingNan.myFloat * VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 9"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 9"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","9");  
  E_DBGR_VariableCheck("testflag",9,Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations9 = VeTEST_FloatSignalingNan.myFloat * VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\45");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\45");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at "VeTEST_InvalidOperations10 = VeTEST_PINF.myFloat * VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 10"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 10"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","10");  
  E_DBGR_VariableCheck("testflag",10,Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations10 = VeTEST_PINF.myFloat * VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\49");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\49"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations9, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations9",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations9 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations11 = VeTEST_NINF.myFloat * VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 11"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 11"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","11");  
  E_DBGR_VariableCheck("testflag",11,Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations11 = VeTEST_NINF.myFloat * VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\53");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\53");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the VeTEST_InvalidOperations10, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations10",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations10 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
    
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Verify the VeTEST_InvalidOperations11, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations11",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations11 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686941: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined DIV Core 0
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_DIV_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_DIV_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686941", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core0 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core0_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core0_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core0_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations12 = VeTEST_FloatSignalingNan.myFloat / VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 12"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 12"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","12");  
  E_DBGR_VariableCheck("testflag",12,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations12 = VeTEST_FloatSignalingNan.myFloat / VeTEST_FloatPos; inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\57");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\57");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at "VeTEST_InvalidOperations13 = VeTEST_PINF.myFloat / VeTEST_PINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 13"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 13"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","13");  
  E_DBGR_VariableCheck("testflag",13,Equal);
    
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations13 = VeTEST_PINF.myFloat / VeTEST_PINF.myFloat; inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\61");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\61");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations12, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations12",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations12 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go();    
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations14 = VeTEST_PINF.myFloat / VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 14"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 14"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","14");  
  E_DBGR_VariableCheck("testflag",14,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations14 = VeTEST_PINF.myFloat / VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\65");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\65"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the VeTEST_InvalidOperations13, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations13",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations13 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");   
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 12: Set a breakpoint at "VeTEST_InvalidOperations15 = VeTEST_NINF.myFloat/ VeTEST_PINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 15"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 15"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","15");  
  E_DBGR_VariableCheck("testflag",15,Equal);
    
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations15 = VeTEST_NINF.myFloat/ VeTEST_PINF.myFloat; inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\69");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\69");  
  
    /*******************************************************************************************************************************************************/    
    // Test Step 13: Verify the VeTEST_InvalidOperations14, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations14",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations14 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 15: Set a breakpoint at "VeTEST_InvalidOperations16 = VeTEST_NINF.myFloat/ VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 16"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 16"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","16");  
  E_DBGR_VariableCheck("testflag",16,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations16 = VeTEST_NINF.myFloat/ VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\73");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\73");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 16: Verify the VeTEST_InvalidOperations15, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations15",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations15 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",4,Equal);
    
  /*******************************************************************************************************************************************************/    
    // Test Step 17: Verify the VeTEST_InvalidOperations16, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();  
  A_DBGR_VariableRead("VeTEST_InvalidOperations16",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations16 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",5,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686947: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined CMP Core 0
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_CMP_Core0()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_CMP_Core0" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686947", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core0 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core0_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core0_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core0_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core0 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core0 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core0","1");
  E_DBGR_VariableCheck("FPU_Core0",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",0,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations17 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatPos);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 17"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 17"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","17");  
  E_DBGR_VariableCheck("testflag",17,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations17 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatPos); inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\77");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\77");  

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 
   
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the VeTEST_InvalidOperations17 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations17 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations17 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperations17",0.0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 7: Set a breakpoint at "VeTEST_InvalidOperations18 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatDenorm1.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 18"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 18"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","18");  
  E_DBGR_VariableCheck("testflag",18,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations18 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatDenorm1.myFloat); inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\81");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\81");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);  

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 
   
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Verify the VeTEST_InvalidOperations18 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations18 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations18 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperations18",0.0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Set a breakpoint at "VeTEST_InvalidOperations19 = (VeTEST_FloatDenorm2.myFloat == VeTEST_FloatSignalingNan.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 19"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 19"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","19");  
  E_DBGR_VariableCheck("testflag",19,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations19 = (VeTEST_FloatDenorm2.myFloat == VeTEST_FloatSignalingNan.myFloat); inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\85");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\85"); 
  
    /*******************************************************************************************************************************************************/    
    // Test Step 11: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go(); 
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 12: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11"); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
   
  /*******************************************************************************************************************************************************/    
    // Test Step 13: Verify the VeTEST_InvalidOperations19 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations19 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations19 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperations19",0.0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at "VeTEST_InvalidOperations20 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatSignalingNan.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 20"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 20"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","20");  
  E_DBGR_VariableCheck("testflag",20,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations20 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatSignalingNan.myFloat); inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\89");    
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\89");  
  
    /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go(); 
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 16: Verify the VeTEST_InvalidOperations20 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations20 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations20 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperations20",0.0,Equal);
    
  /*******************************************************************************************************************************************************/    
    // Test Step 17: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",4,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686068: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined x/NaN Core 1
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_x_NaN_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_x_NaN_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686068", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core1_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core1_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core1_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations1 = VeTEST_DivByZeroNum / VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 1"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "1");  
  E_DBGR_VariableCheck("testflag", 1, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations1 = VeTEST_DivByZeroNum / VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\13");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\13");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at test_exc_address = GetHWIO_Ptr_FP_Exception(coreId); inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at test_exc_address = GetHWIO_Ptr_FP_Exception(coreId);; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at test_exc_cnt = GetHWIO_Cnt_FP_Exceptions(coreId); inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
   
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at test_exc_cnt = GetHWIO_Cnt_FP_Exceptions(coreId); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\7");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\7");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations1, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations1",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations1 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686916: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined FLOAT to fixed point conversions Core 1
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_FLOAT_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_FLOAT_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686916", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core1_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core1_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core1_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations2 = (LONGWORD) VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 2"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "2");  
  E_DBGR_VariableCheck("testflag", 2, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations2 = (LONGWORD) VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\17");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\17");   
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
   
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the VeTEST_InvalidOperations2 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations2 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperations2",0.0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 7: Set a breakpoint at "VeTEST_InvalidOperations3 = (LONGINT) VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
 
  snprintf( chActionText, elCount(chActionText), "Set testflag = 3"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "3");  
  E_DBGR_VariableCheck("testflag", 3, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations3 = (LONGINT) VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\21");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\21");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Verify the VeTEST_InvalidOperations3 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations3 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations3 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_VariableCheck("VeTEST_InvalidOperations3",0.0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686922: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined ADD Core 1
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_ADD_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_ADD_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686922", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core1_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core1_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core1_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations4 = VeTEST_FloatSignalingNan.myFloat + VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 4"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 4"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "4");  
  E_DBGR_VariableCheck("testflag", 4, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations4 = VeTEST_FloatSignalingNan.myFloat + VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\25");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\25");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");   

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at "VeTEST_InvalidOperations5 = VeTEST_PINF.myFloat + VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 5"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 5"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "5");  
  E_DBGR_VariableCheck("testflag", 5, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations5 = VeTEST_PINF.myFloat + VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\29");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\29");  
    
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations4, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations4",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations4 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations5",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations5 = %ld", VeTEST_InvalidOperations_value_NAN);  
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);   
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686928: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined SUB Core 1
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_SUB_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_SUB_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686928", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core1_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core1_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core1_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations6 = VeTEST_FloatSignalingNan.myFloat - VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 6"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 6"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "6");  
  E_DBGR_VariableCheck("testflag", 6, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations6 = VeTEST_FloatSignalingNan.myFloat - VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\33");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\33");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");    

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at "VeTEST_InvalidOperations7 = VeTEST_aINF.myFloat - VeTEST_bINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 7"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 7"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "7");  
  E_DBGR_VariableCheck("testflag", 7, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations7 = VeTEST_aINF.myFloat - VeTEST_bINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\37");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\37");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations6, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations6",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations6 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations8 = VeTEST_cINF.myFloat - VeTEST_dINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 8"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 8"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "8");  
  E_DBGR_VariableCheck("testflag", 8, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations8 = VeTEST_cINF.myFloat - VeTEST_dINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\41");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\41");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the VeTEST_InvalidOperations7, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations7",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations7 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
    
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Verify the VeTEST_InvalidOperations8, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations8",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations8 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686936: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined MUL Core 1
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_MUL_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_MUL_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686936", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core1_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core1_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core1_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal); 
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations9 = VeTEST_FloatSignalingNan.myFloat * VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 9"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 9"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","9");  
  E_DBGR_VariableCheck("testflag",9,Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations9 = VeTEST_FloatSignalingNan.myFloat * VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\45");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\45");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at "VeTEST_InvalidOperations10 = VeTEST_PINF.myFloat * VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 10"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 10"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","10");  
  E_DBGR_VariableCheck("testflag",10,Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations10 = VeTEST_PINF.myFloat * VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\49");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\49"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations9, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations9",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations9 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations11 = VeTEST_NINF.myFloat * VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 11"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 11"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","11");  
  E_DBGR_VariableCheck("testflag",11,Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations11 = VeTEST_NINF.myFloat * VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\53");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\53");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the VeTEST_InvalidOperations10, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations10",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations10 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
    
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Verify the VeTEST_InvalidOperations11, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations11",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations11 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686942: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined DIV Core 1
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_DIV_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_DIV_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686942", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core1_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core1_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core1_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations12 = VeTEST_FloatSignalingNan.myFloat / VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 12"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 12"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","12");  
  E_DBGR_VariableCheck("testflag",12,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations12 = VeTEST_FloatSignalingNan.myFloat / VeTEST_FloatPos; inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\57");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\57");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at "VeTEST_InvalidOperations13 = VeTEST_PINF.myFloat / VeTEST_PINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 13"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 13"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","13");  
  E_DBGR_VariableCheck("testflag",13,Equal);
    
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations13 = VeTEST_PINF.myFloat / VeTEST_PINF.myFloat; inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\61");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\61");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations12, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations12",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations12 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go();    
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations14 = VeTEST_PINF.myFloat / VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 14"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 14"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","14");  
  E_DBGR_VariableCheck("testflag",14,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations14 = VeTEST_PINF.myFloat / VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\65");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\65"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the VeTEST_InvalidOperations13, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations13",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations13 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");   
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 12: Set a breakpoint at "VeTEST_InvalidOperations15 = VeTEST_NINF.myFloat/ VeTEST_PINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 15"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 15"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","15");  
  E_DBGR_VariableCheck("testflag",15,Equal);
    
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations15 = VeTEST_NINF.myFloat/ VeTEST_PINF.myFloat; inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\69");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\69");  
  
    /*******************************************************************************************************************************************************/    
    // Test Step 13: Verify the VeTEST_InvalidOperations14, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations14",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations14 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 15: Set a breakpoint at "VeTEST_InvalidOperations16 = VeTEST_NINF.myFloat/ VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 16"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 16"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","16");  
  E_DBGR_VariableCheck("testflag",16,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations16 = VeTEST_NINF.myFloat/ VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\73");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\73");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 16: Verify the VeTEST_InvalidOperations15, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations15",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations15 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",4,Equal);
    
  /*******************************************************************************************************************************************************/    
    // Test Step 17: Verify the VeTEST_InvalidOperations16, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();  
  A_DBGR_VariableRead("VeTEST_InvalidOperations16",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations16 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",5,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686948: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined CMP Core 1
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_CMP_Core1()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_CMP_Core1" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686948", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core1 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core1_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core1_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core1_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core1 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core1 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core1","1");
  E_DBGR_VariableCheck("FPU_Core1",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",1,Equal); 
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations17 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatPos);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 17"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 17"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","17");  
  E_DBGR_VariableCheck("testflag",17,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations17 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatPos); inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\77");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\77");  

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 
   
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the VeTEST_InvalidOperations17 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations17 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations17 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperations17",0.0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 7: Set a breakpoint at "VeTEST_InvalidOperations18 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatDenorm1.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 18"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 18"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","18");  
  E_DBGR_VariableCheck("testflag",18,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations18 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatDenorm1.myFloat); inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\81");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\81");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);  

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 
   
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Verify the VeTEST_InvalidOperations18 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations18 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations18 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperations18",0.0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Set a breakpoint at "VeTEST_InvalidOperations19 = (VeTEST_FloatDenorm2.myFloat == VeTEST_FloatSignalingNan.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 19"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 19"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","19");  
  E_DBGR_VariableCheck("testflag",19,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations19 = (VeTEST_FloatDenorm2.myFloat == VeTEST_FloatSignalingNan.myFloat); inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\85");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\85"); 
  
    /*******************************************************************************************************************************************************/    
    // Test Step 11: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go(); 
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 12: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11"); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
   
  /*******************************************************************************************************************************************************/    
    // Test Step 13: Verify the VeTEST_InvalidOperations19 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations19 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations19 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperations19",0.0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at "VeTEST_InvalidOperations20 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatSignalingNan.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 20"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 20"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","20");  
  E_DBGR_VariableCheck("testflag",20,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations20 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatSignalingNan.myFloat); inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\89");    
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\89");  
  
    /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go(); 
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 16: Verify the VeTEST_InvalidOperations20 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations20 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations20 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperations20",0.0,Equal);
    
  /*******************************************************************************************************************************************************/    
    // Test Step 17: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",4,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686067: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined x/NaN Core 2
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_x_NaN_Core2()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_x_NaN_Core2" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686067", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core2_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core2_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core2_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",2,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations1 = VeTEST_DivByZeroNum / VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 1"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "1");  
  E_DBGR_VariableCheck("testflag", 1, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations1 = VeTEST_DivByZeroNum / VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\13");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\13");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at test_exc_address = GetHWIO_Ptr_FP_Exception(coreId); inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at test_exc_address = GetHWIO_Ptr_FP_Exception(coreId);; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at test_exc_cnt = GetHWIO_Cnt_FP_Exceptions(coreId); inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
   
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at test_exc_cnt = GetHWIO_Cnt_FP_Exceptions(coreId); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\7");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\7");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations1, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations1",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations1 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686917: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined FLOAT to fixed point conversions Core 2
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_FLOAT_Core2()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_FLOAT_Core2" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686917", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
    /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core2_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core2_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core2_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",2,Equal); 
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations2 = (LONGWORD) VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 2"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "2");  
  E_DBGR_VariableCheck("testflag", 2, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations2 = (LONGWORD) VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\17");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\17");   
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
   
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the VeTEST_InvalidOperations2 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations2 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperations2",0.0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 7: Set a breakpoint at "VeTEST_InvalidOperations3 = (LONGINT) VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
 
  snprintf( chActionText, elCount(chActionText), "Set testflag = 3"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "3");  
  E_DBGR_VariableCheck("testflag", 3, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations3 = (LONGINT) VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\21");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\21");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Verify the VeTEST_InvalidOperations3 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations3 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations3 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_VariableCheck("VeTEST_InvalidOperations3",0.0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686923: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined ADD Core 2
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_ADD_Core2()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_ADD_Core2" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686923", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
    /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core2_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core2_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core2_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",2,Equal); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations4 = VeTEST_FloatSignalingNan.myFloat + VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 4"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 4"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "4");  
  E_DBGR_VariableCheck("testflag", 4, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations4 = VeTEST_FloatSignalingNan.myFloat + VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\25");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\25");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");   

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at "VeTEST_InvalidOperations5 = VeTEST_PINF.myFloat + VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 5"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 5"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "5");  
  E_DBGR_VariableCheck("testflag", 5, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations5 = VeTEST_PINF.myFloat + VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\29");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\29");  
    
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations4, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations4",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations4 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations5",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations5 = %ld", VeTEST_InvalidOperations_value_NAN);  
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);   
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686929: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined SUB Core 2
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_SUB_Core2()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_SUB_Core2" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686929", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
    /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core2_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core2_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core2_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",2,Equal); 
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations6 = VeTEST_FloatSignalingNan.myFloat - VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 6"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 6"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "6");  
  E_DBGR_VariableCheck("testflag", 6, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations6 = VeTEST_FloatSignalingNan.myFloat - VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\33");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\33");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");    

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at "VeTEST_InvalidOperations7 = VeTEST_aINF.myFloat - VeTEST_bINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 7"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 7"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "7");  
  E_DBGR_VariableCheck("testflag", 7, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations7 = VeTEST_aINF.myFloat - VeTEST_bINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\37");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\37");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations6, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations6",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations6 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations8 = VeTEST_cINF.myFloat - VeTEST_dINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 8"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 8"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "8");  
  E_DBGR_VariableCheck("testflag", 8, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations8 = VeTEST_cINF.myFloat - VeTEST_dINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\41");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\41");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the VeTEST_InvalidOperations7, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations7",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations7 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
    
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Verify the VeTEST_InvalidOperations8, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations8",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations8 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686937: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined MUL Core 2
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_MUL_Core2()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_MUL_Core2" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686937", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
    /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core2_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core2_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core2_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",2,Equal); 
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations9 = VeTEST_FloatSignalingNan.myFloat * VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 9"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 9"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","9");  
  E_DBGR_VariableCheck("testflag",9,Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations9 = VeTEST_FloatSignalingNan.myFloat * VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\45");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\45");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at "VeTEST_InvalidOperations10 = VeTEST_PINF.myFloat * VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 10"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 10"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","10");  
  E_DBGR_VariableCheck("testflag",10,Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations10 = VeTEST_PINF.myFloat * VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\49");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\49"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations9, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations9",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations9 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations11 = VeTEST_NINF.myFloat * VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 11"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 11"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","11");  
  E_DBGR_VariableCheck("testflag",11,Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations11 = VeTEST_NINF.myFloat * VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\53");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\53");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the VeTEST_InvalidOperations10, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations10",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations10 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
    
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Verify the VeTEST_InvalidOperations11, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations11",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations11 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686943: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined DIV Core 2
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_DIV_Core2()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_DIV_Core2" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686943", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
    /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core2_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core2_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core2_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",2,Equal); 
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations12 = VeTEST_FloatSignalingNan.myFloat / VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 12"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 12"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","12");  
  E_DBGR_VariableCheck("testflag",12,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations12 = VeTEST_FloatSignalingNan.myFloat / VeTEST_FloatPos; inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\57");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\57");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at "VeTEST_InvalidOperations13 = VeTEST_PINF.myFloat / VeTEST_PINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 13"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 13"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","13");  
  E_DBGR_VariableCheck("testflag",13,Equal);
    
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations13 = VeTEST_PINF.myFloat / VeTEST_PINF.myFloat; inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\61");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\61");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations12, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations12",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations12 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go();    
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations14 = VeTEST_PINF.myFloat / VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 14"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 14"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","14");  
  E_DBGR_VariableCheck("testflag",14,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations14 = VeTEST_PINF.myFloat / VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\65");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\65"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the VeTEST_InvalidOperations13, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations13",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations13 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");   
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 12: Set a breakpoint at "VeTEST_InvalidOperations15 = VeTEST_NINF.myFloat/ VeTEST_PINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 15"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 15"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","15");  
  E_DBGR_VariableCheck("testflag",15,Equal);
    
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations15 = VeTEST_NINF.myFloat/ VeTEST_PINF.myFloat; inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\69");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\69");  
  
    /*******************************************************************************************************************************************************/    
    // Test Step 13: Verify the VeTEST_InvalidOperations14, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations14",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations14 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 15: Set a breakpoint at "VeTEST_InvalidOperations16 = VeTEST_NINF.myFloat/ VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 16"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 16"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","16");  
  E_DBGR_VariableCheck("testflag",16,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations16 = VeTEST_NINF.myFloat/ VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\73");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\73");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 16: Verify the VeTEST_InvalidOperations15, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations15",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations15 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",4,Equal);
    
  /*******************************************************************************************************************************************************/    
    // Test Step 17: Verify the VeTEST_InvalidOperations16, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();  
  A_DBGR_VariableRead("VeTEST_InvalidOperations16",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations16 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",5,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686949: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined CMP Core 2
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_CMP_Core2()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_CMP_Core2" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686949", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
    /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core2 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core2_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core2_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core2_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core2 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core2 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core2","1");
  E_DBGR_VariableCheck("FPU_Core2",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",2,Equal); 
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations17 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatPos);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 17"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 17"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","17");  
  E_DBGR_VariableCheck("testflag",17,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations17 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatPos); inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\77");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\77");  

  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 
   
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the VeTEST_InvalidOperations17 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations17 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations17 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperations17",0.0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 7: Set a breakpoint at "VeTEST_InvalidOperations18 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatDenorm1.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 18"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 18"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","18");  
  E_DBGR_VariableCheck("testflag",18,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations18 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatDenorm1.myFloat); inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\81");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\81");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);  

  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 
   
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Verify the VeTEST_InvalidOperations18 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations18 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations18 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperations18",0.0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Set a breakpoint at "VeTEST_InvalidOperations19 = (VeTEST_FloatDenorm2.myFloat == VeTEST_FloatSignalingNan.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 19"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 19"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","19");  
  E_DBGR_VariableCheck("testflag",19,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations19 = (VeTEST_FloatDenorm2.myFloat == VeTEST_FloatSignalingNan.myFloat); inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\85");  
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\85"); 
  
    /*******************************************************************************************************************************************************/    
    // Test Step 11: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go(); 
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 12: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11"); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
   
  /*******************************************************************************************************************************************************/    
    // Test Step 13: Verify the VeTEST_InvalidOperations19 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations19 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations19 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperations19",0.0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 14: Set a breakpoint at "VeTEST_InvalidOperations20 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatSignalingNan.myFloat);" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 20"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 20"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","20");  
  E_DBGR_VariableCheck("testflag",20,Equal);  
  
//  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations20 = (VeTEST_FloatSignalingNan.myFloat == VeTEST_FloatSignalingNan.myFloat); inside Test_Float(void) function."); 
//  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
//  TestStepAddActionExpected( chActionText, chExpectedText );  
//  A_DBGR_BreakpointSet("Test_Float\\89");    
//  A_DBGR_Go();
//  E_DBGR_BreakpointCheckForHalt("Test_Float\\89");  
  
    /*******************************************************************************************************************************************************/    
    // Test Step 15: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go(); 
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 16: Verify the VeTEST_InvalidOperations20 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations20 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations20 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperations20",0.0,Equal);
    
  /*******************************************************************************************************************************************************/    
    // Test Step 17: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",4,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686071: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined x/NaN Core 3
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_x_NaN_Core3()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_x_NaN_Core3" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686071", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core3_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core3_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core3_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",3,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations1 = VeTEST_DivByZeroNum / VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 1"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "1");  
  E_DBGR_VariableCheck("testflag", 1, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations1 = VeTEST_DivByZeroNum / VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\13");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\13");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at test_exc_address = GetHWIO_Ptr_FP_Exception(coreId); inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\2");  
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\2");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at test_exc_address = GetHWIO_Ptr_FP_Exception(coreId);; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at test_exc_cnt = GetHWIO_Cnt_FP_Exceptions(coreId); inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
   
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at test_exc_cnt = GetHWIO_Cnt_FP_Exceptions(coreId); inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\7");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\7");
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations1, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations1",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations1 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686918: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined FLOAT to fixed point conversions Core 3
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_FLOAT_Core3()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_FLOAT_Core3" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686918", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core3_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core3_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core3_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",3,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations2 = (LONGWORD) VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 2"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "2");  
  E_DBGR_VariableCheck("testflag", 2, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations2 = (LONGWORD) VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\17");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\17");   
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
   
  /*******************************************************************************************************************************************************/    
    // Test Step 6: Verify the VeTEST_InvalidOperations2 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations2 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations2 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("VeTEST_InvalidOperations2",0.0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 7: Set a breakpoint at "VeTEST_InvalidOperations3 = (LONGINT) VeTEST_FloatSignalingNan.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
 
  snprintf( chActionText, elCount(chActionText), "Set testflag = 3"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "3");  
  E_DBGR_VariableCheck("testflag", 3, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations3 = (LONGINT) VeTEST_FloatSignalingNan.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\21");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\21");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Verify the VeTEST_InvalidOperations3 value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the VeTEST_InvalidOperations3 value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "VeTEST_InvalidOperations3 is 0.0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  E_DBGR_VariableCheck("VeTEST_InvalidOperations3",0.0,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686924: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined ADD Core 3
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_ADD_Core3()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_ADD_Core3" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686924", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core3_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core3_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core3_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",3,Equal);
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations4 = VeTEST_FloatSignalingNan.myFloat + VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 4"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 4"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "4");  
  E_DBGR_VariableCheck("testflag", 4, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations4 = VeTEST_FloatSignalingNan.myFloat + VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\25");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\25");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");   

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at "VeTEST_InvalidOperations5 = VeTEST_PINF.myFloat + VeTEST_NINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 5"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 5"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "5");  
  E_DBGR_VariableCheck("testflag", 5, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations5 = VeTEST_PINF.myFloat + VeTEST_NINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\29");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\29");  
    
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations4, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations4",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations4 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations5",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations5 = %ld", VeTEST_InvalidOperations_value_NAN);  
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);   
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686930: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined SUB Core 3
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_SUB_Core3()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_SUB_Core3" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686930", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core3_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core3_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core3_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");
 
  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",3,Equal);  
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations6 = VeTEST_FloatSignalingNan.myFloat - VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 6"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 6"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "6");  
  E_DBGR_VariableCheck("testflag", 6, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations6 = VeTEST_FloatSignalingNan.myFloat - VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\33");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\33");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");    

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at "VeTEST_InvalidOperations7 = VeTEST_aINF.myFloat - VeTEST_bINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 7"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 7"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "7");  
  E_DBGR_VariableCheck("testflag", 7, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations7 = VeTEST_aINF.myFloat - VeTEST_bINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\37");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\37");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations6, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations6",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations6 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations8 = VeTEST_cINF.myFloat - VeTEST_dINF.myFloat;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 8"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 8"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag", "8");  
  E_DBGR_VariableCheck("testflag", 8, Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations8 = VeTEST_cINF.myFloat - VeTEST_dINF.myFloat; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\41");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\41");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the VeTEST_InvalidOperations7, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations7",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations7 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
    
  /*******************************************************************************************************************************************************/    
    // Test Step 11: Verify the VeTEST_InvalidOperations8, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_Go();
  A_DBGR_VariableRead("VeTEST_InvalidOperations8",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations8 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",3,Equal);
}

/***************************************************************************************************
----------------------------------------------------------------------------------------------------
Test case name:  TC_L30SW_QT_36686938: Verify Invalid Operations with FP_CONFIG_INIHIBIT_RESET defined MUL Core 3
----------------------------------------------------------------------------------------------------
Description:   The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.

***************************************************************************************************/
testcase Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_MUL_Core3()
{
  /***************************************************************************************************************/    
                                                // Variable Definition
  /***************************************************************************************************************/ 
  
  long taskvalue;
  
  /***************************************************************************************************************/    
                                               // Local Values
  /***************************************************************************************************************/ 
  

  
  /***************************************************************************************************************/    
                                              // Test Case Info
  /***************************************************************************************************************/
  
  setWriteDbgLevel(DebugOff);
  snprintf( chTestTitle, elCount(chTestTitle), "Testcase_Verify_Invalid_Operations_FP_CONFIG_INIHIBIT_RESET_defined_MUL_Core3" );
  snprintf( chTestDescription, elCount(chTestDescription), "Purpose:The FP_Config_Inihibit_Reset interface shall, when defined, prevent the Floating-Point Exception Running Reset from occurring.");
  TestCaseAddInfo( chTestTitle, "TC_L30SW_QT_36686938", chTestDescription );

  /***************************************************************************************************************/    
                                              // Start of Test Case
  /***************************************************************************************************************/
  
  /***************************************************************************************************************/    
                                              // Test Step 1 PRECONDITIONS
  /***************************************************************************************************************/
  
  /*******************************************************************************************************************************************************/    
    // Test Step 1: Configure FPU_Core3 mode
  /*******************************************************************************************************************************************************/
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at Os_Entry_Task_Core3_1000ms and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointDeleteAll();
  A_DBGR_R();
  A_DBGR_BreakpointSet("Os_Entry_Task_Core3_1000ms\\2");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Os_Entry_Task_Core3_1000ms\\2");
  
  snprintf( chActionText, elCount(chActionText), "Configure FPU_Core3 mode"); 
  snprintf( chExpectedText, elCount(chExpectedText), "verify Configure FPU_Core3 mode"); 
  TestStepAddActionExpected( chActionText, chExpectedText ); 
  A_DBGR_VariableSet("FPU_Core3","1");
  E_DBGR_VariableCheck("FPU_Core3",1,Equal);
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at BYTE coreId = GetHWIO_e_CPU(); inside Test_Float(void) function and run the application"); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\5");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\5");

  /*******************************************************************************************************************************************************/    
    // Test Step 2: Verify the coreId
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the coreId"); 
  snprintf( chExpectedText, elCount(chExpectedText), "coreId is 3"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  E_DBGR_VariableCheck("coreId",3,Equal); 
 
  /*******************************************************************************************************************************************************/    
    // Test Step 3: Verify the test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0 and test_exc_cnt is 0"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value);  
  E_DBGR_VariableCheck("test_exc_cnt",0,Equal);

  /*******************************************************************************************************************************************************/    
    // Test Step 4: Set a breakpoint at "VeTEST_InvalidOperations9 = VeTEST_FloatSignalingNan.myFloat * VeTEST_FloatPos;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
    
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  snprintf( chActionText, elCount(chActionText), "Set testflag = 9"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 9"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","9");  
  E_DBGR_VariableCheck("testflag",9,Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations9 = VeTEST_FloatSignalingNan.myFloat * VeTEST_FloatPos; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\45");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\45");  
  
  /*******************************************************************************************************************************************************/    
    // Test Step 5: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");

  /*******************************************************************************************************************************************************/    
    // Test Step 6: Set a breakpoint at "VeTEST_InvalidOperations10 = VeTEST_PINF.myFloat * VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 10"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 10"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","10");  
  E_DBGR_VariableCheck("testflag",10,Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations10 = VeTEST_PINF.myFloat * VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\49");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\49"); 
  
  /*******************************************************************************************************************************************************/    
    // Test Step 7: Verify the VeTEST_InvalidOperations9, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 1"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations9",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations9 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",1,Equal);
  
  /*******************************************************************************************************************************************************/    
    // Test Step 8: Set a breakpoint at if (testflag == 1) inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at if (testflag == 1) inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\11");  
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  A_DBGR_Go(); 
  E_DBGR_BreakpointCheckForHalt("Test_Float\\11");
  
  /*******************************************************************************************************************************************************/    
    // Test Step 9: Set a breakpoint at "VeTEST_InvalidOperations11 = VeTEST_NINF.myFloat * VeTEST_PosZero;" inside Test_Float(void) function.
  /*******************************************************************************************************************************************************/
     
  snprintf( chActionText, elCount(chActionText), "Set testflag = 11"); 
  snprintf( chExpectedText, elCount(chExpectedText), "testflag = 11"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableSet("testflag","11");  
  E_DBGR_VariableCheck("testflag",11,Equal);  
  
  snprintf( chActionText, elCount(chActionText), "Set a breakpoint at VeTEST_InvalidOperations11 = VeTEST_NINF.myFloat * VeTEST_PosZero; inside Test_Float(void) function."); 
  snprintf( chExpectedText, elCount(chExpectedText), "Breakpoint is set."); 
  TestStepAddActionExpected( chActionText, chExpectedText );  
  A_DBGR_BreakpointSet("Test_Float\\53");  
  A_DBGR_Go();
  E_DBGR_BreakpointCheckForHalt("Test_Float\\53");
    
  /*******************************************************************************************************************************************************/    
    // Test Step 10: Verify the VeTEST_InvalidOperations10, test_exc_address and test_exc_cnt value
  /*******************************************************************************************************************************************************/

  snprintf( chActionText, elCount(chActionText), "Verify the test_exc_address and test_exc_cnt value"); 
  snprintf( chExpectedText, elCount(chExpectedText), "test_exc_address is 0xXXXXXXXX and test_exc_cnt is 2"); 
  TestStepAddActionExpected( chActionText, chExpectedText );
  A_DBGR_VariableRead("VeTEST_InvalidOperations10",VeTEST_InvalidOperations_value_NAN);
  write ("VeTEST_InvalidOperations10 = %ld", VeTEST_InvalidOperations_value_NAN);
  A_DBGR_VariableRead("test_exc_address",test_exc_address_value); 
  write ("test_exc_address = %ld", test_exc_address_value);
  E_DBGR_VariableCheck("test_exc_cnt",2,Equal);
    
